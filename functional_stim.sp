* Functional test stimulus file for 20ns period

* TT process corner
.include "/home/tuan/Desktop/OpenRAM/technology/sky130A/models/tt.sp"
.include "sram_32_512_sky130A.sp"

* Global Power Supplies
Vvdd vdd 0 1.8

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
Xsram_32_512_sky130A din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 a0_7 a0_8 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 vdd gnd sram_32_512_sky130A

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f
CD08 dout0_8  0 39.2968f
CD09 dout0_9  0 39.2968f
CD010 dout0_10  0 39.2968f
CD011 dout0_11  0 39.2968f
CD012 dout0_12  0 39.2968f
CD013 dout0_13  0 39.2968f
CD014 dout0_14  0 39.2968f
CD015 dout0_15  0 39.2968f
CD016 dout0_16  0 39.2968f
CD017 dout0_17  0 39.2968f
CD018 dout0_18  0 39.2968f
CD019 dout0_19  0 39.2968f
CD020 dout0_20  0 39.2968f
CD021 dout0_21  0 39.2968f
CD022 dout0_22  0 39.2968f
CD023 dout0_23  0 39.2968f
CD024 dout0_24  0 39.2968f
CD025 dout0_25  0 39.2968f
CD026 dout0_26  0 39.2968f
CD027 dout0_27  0 39.2968f
CD028 dout0_28  0 39.2968f
CD029 dout0_29  0 39.2968f
CD030 dout0_30  0 39.2968f
CD031 dout0_31  0 39.2968f

* Important signals for debug
* bl:	xsram_32_512_sky130a.xbank0.bl_0_0
* br:	xsram_32_512_sky130a.xbank0.br_0_0
* s_en:	xsram_32_512_sky130a.s_en
* q:	xsram_32_512_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xsram_32_512_sky130A.xbank0.xbitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 20ns)
*	Writing 11011011110001110011101010000101  to  address 000000011 (from port 0) during cycle 1 (20ns - 40ns)
*	Writing 10010001101100000000111010101110  to  address 000000001 (from port 0) during cycle 2 (40ns - 60ns)
*	Writing 00110000000010010101000010010100  to  address 111111101 (from port 0) during cycle 3 (60ns - 80ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 4 (80ns - 100ns)
*	Writing 01101100111010100111011000000011  to  address 111111100 (from port 0) during cycle 5 (100ns - 120ns)
*	Reading 01101100111010100111011000000011 from address 111111100 (from port 0) during cycle 6 (120ns - 140ns)
*	Reading 01101100111010100111011000000011 from address 111111100 (from port 0) during cycle 7 (140ns - 160ns)
*	Reading 00110000000010010101000010010100 from address 111111101 (from port 0) during cycle 8 (160ns - 180ns)
*	Writing 10001101111011111100100100010000  to  address 111111101 (from port 0) during cycle 9 (180ns - 200ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 10 (200ns - 220ns)
*	Reading 01101100111010100111011000000011 from address 111111100 (from port 0) during cycle 12 (240ns - 260ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 13 (260ns - 280ns)
*	Writing 11010001011101111101100001001111  to  address 111111100 (from port 0) during cycle 15 (300ns - 320ns)
*	Reading 10001101111011111100100100010000 from address 111111101 (from port 0) during cycle 16 (320ns - 340ns)
*	Reading 11011011110001110011101010000101 from address 000000011 (from port 0) during cycle 17 (340ns - 360ns)
*	Reading 11011011110001110011101010000101 from address 000000011 (from port 0) during cycle 18 (360ns - 380ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 19 (380ns - 400ns)
*	Writing 11011001001111010101000000100111  to  address 000000011 (from port 0) during cycle 21 (420ns - 440ns)
*	Writing 10010111010111011000010001100101  to  address 111111011 (from port 0) during cycle 22 (440ns - 460ns)
*	Reading 10001101111011111100100100010000 from address 111111101 (from port 0) during cycle 24 (480ns - 500ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 25 (500ns - 520ns)
*	Reading 11011001001111010101000000100111 from address 000000011 (from port 0) during cycle 26 (520ns - 540ns)
*	Reading 11010001011101111101100001001111 from address 111111100 (from port 0) during cycle 27 (540ns - 560ns)
*	Reading 10001101111011111100100100010000 from address 111111101 (from port 0) during cycle 28 (560ns - 580ns)
*	Reading 10001101111011111100100100010000 from address 111111101 (from port 0) during cycle 29 (580ns - 600ns)
*	Reading 11011001001111010101000000100111 from address 000000011 (from port 0) during cycle 30 (600ns - 620ns)
*	Reading 11011001001111010101000000100111 from address 000000011 (from port 0) during cycle 31 (620ns - 640ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 33 (660ns - 680ns)
*	Reading 10001101111011111100100100010000 from address 111111101 (from port 0) during cycle 39 (780ns - 800ns)
*	Reading 10001101111011111100100100010000 from address 111111101 (from port 0) during cycle 41 (820ns - 840ns)
*	Reading 11011001001111010101000000100111 from address 000000011 (from port 0) during cycle 42 (840ns - 860ns)
*	Reading 10010111010111011000010001100101 from address 111111011 (from port 0) during cycle 44 (880ns - 900ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 46 (920ns - 940ns)
*	Reading 11010001011101111101100001001111 from address 111111100 (from port 0) during cycle 47 (940ns - 960ns)
*	Reading 10010111010111011000010001100101 from address 111111011 (from port 0) during cycle 48 (960ns - 980ns)
*	Reading 10010111010111011000010001100101 from address 111111011 (from port 0) during cycle 50 (1000ns - 1020ns)
*	Reading 10001101111011111100100100010000 from address 111111101 (from port 0) during cycle 51 (1020ns - 1040ns)
*	Reading 11011001001111010101000000100111 from address 000000011 (from port 0) during cycle 53 (1060ns - 1080ns)
*	Reading 11010001011101111101100001001111 from address 111111100 (from port 0) during cycle 55 (1100ns - 1120ns)
*	Writing 10101000001000111001101000000111  to  address 000000010 (from port 0) during cycle 56 (1120ns - 1140ns)
*	Writing 10010111101011110110100110000000  to  address 111111011 (from port 0) during cycle 57 (1140ns - 1160ns)
*	Writing 11000000000100001111010100111101  to  address 000000000 (from port 0) during cycle 58 (1160ns - 1180ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 61 (1220ns - 1240ns)
*	Reading 10010111101011110110100110000000 from address 111111011 (from port 0) during cycle 62 (1240ns - 1260ns)
*	Writing 01110110110101011101011110010100  to  address 000000000 (from port 0) during cycle 63 (1260ns - 1280ns)
*	Reading 10101000001000111001101000000111 from address 000000010 (from port 0) during cycle 64 (1280ns - 1300ns)
*	Reading 01110110110101011101011110010100 from address 000000000 (from port 0) during cycle 65 (1300ns - 1320ns)
*	Reading 10001101111011111100100100010000 from address 111111101 (from port 0) during cycle 66 (1320ns - 1340ns)
*	Writing 01111011101000001101000011111110  to  address 000000011 (from port 0) during cycle 69 (1380ns - 1400ns)
*	Writing 11100111011101100100111101111101  to  address 111111101 (from port 0) during cycle 70 (1400ns - 1420ns)
*	Writing 00100011110000011111001110001001  to  address 000000010 (from port 0) during cycle 71 (1420ns - 1440ns)
*	Reading 11100111011101100100111101111101 from address 111111101 (from port 0) during cycle 72 (1440ns - 1460ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 74 (1480ns - 1500ns)
*	Writing 11111101111100101110010100110101  to  address 111111101 (from port 0) during cycle 75 (1500ns - 1520ns)
*	Reading 00100011110000011111001110001001 from address 000000010 (from port 0) during cycle 76 (1520ns - 1540ns)
*	Reading 11010001011101111101100001001111 from address 111111100 (from port 0) during cycle 77 (1540ns - 1560ns)
*	Writing 01000101001110111111111000011010  to  address 111111110 (from port 0) during cycle 78 (1560ns - 1580ns)
*	Reading 11010001011101111101100001001111 from address 111111100 (from port 0) during cycle 79 (1580ns - 1600ns)
*	Reading 01000101001110111111111000011010 from address 111111110 (from port 0) during cycle 80 (1600ns - 1620ns)
*	Reading 11010001011101111101100001001111 from address 111111100 (from port 0) during cycle 81 (1620ns - 1640ns)
*	Reading 01110110110101011101011110010100 from address 000000000 (from port 0) during cycle 82 (1640ns - 1660ns)
*	Reading 11010001011101111101100001001111 from address 111111100 (from port 0) during cycle 83 (1660ns - 1680ns)
*	Reading 10010111101011110110100110000000 from address 111111011 (from port 0) during cycle 86 (1720ns - 1740ns)
*	Writing 00010100001000001001101010110001  to  address 111111100 (from port 0) during cycle 88 (1760ns - 1780ns)
*	Writing 01110010110101100010001000010000  to  address 000000000 (from port 0) during cycle 90 (1800ns - 1820ns)
*	Reading 01110010110101100010001000010000 from address 000000000 (from port 0) during cycle 91 (1820ns - 1840ns)
*	Reading 10010001101100000000111010101110 from address 000000001 (from port 0) during cycle 92 (1840ns - 1860ns)
*	Reading 01000101001110111111111000011010 from address 111111110 (from port 0) during cycle 93 (1860ns - 1880ns)
*	Writing 01100111101010000010011110010010  to  address 000000001 (from port 0) during cycle 94 (1880ns - 1900ns)
*	Reading 01100111101010000010011110010010 from address 000000001 (from port 0) during cycle 95 (1900ns - 1920ns)
*	Reading 10010111101011110110100110000000 from address 111111011 (from port 0) during cycle 96 (1920ns - 1940ns)
*	Reading 00100011110000011111001110001001 from address 000000010 (from port 0) during cycle 97 (1940ns - 1960ns)
*	Writing 01110101000000011010010110010010  to  address 111111100 (from port 0) during cycle 98 (1960ns - 1980ns)
*	Reading 11111101111100101110010100110101 from address 111111101 (from port 0) during cycle 99 (1980ns - 2000ns)
*	Writing 11010001011100011010110110011010  to  address 111111100 (from port 0) during cycle 100 (2000ns - 2020ns)
*	Writing 10001111100001010111001000111100  to  address 000000000 (from port 0) during cycle 101 (2020ns - 2040ns)
*	Reading 10001111100001010111001000111100 from address 000000000 (from port 0) during cycle 102 (2040ns - 2060ns)
*	Reading 11010001011100011010110110011010 from address 111111100 (from port 0) during cycle 105 (2100ns - 2120ns)
*	Reading 11111101111100101110010100110101 from address 111111101 (from port 0) during cycle 107 (2140ns - 2160ns)
*	Writing 00000100010110001100001101101001  to  address 111111101 (from port 0) during cycle 108 (2160ns - 2180ns)
*	Writing 01001000011101111111111011001100  to  address 111111011 (from port 0) during cycle 109 (2180ns - 2200ns)
*	Writing 01000010000101011001101101011100  to  address 000000010 (from port 0) during cycle 110 (2200ns - 2220ns)
*	Reading 01100111101010000010011110010010 from address 000000001 (from port 0) during cycle 111 (2220ns - 2240ns)
*	Reading 01111011101000001101000011111110 from address 000000011 (from port 0) during cycle 112 (2240ns - 2260ns)
*	Reading 01000101001110111111111000011010 from address 111111110 (from port 0) during cycle 113 (2260ns - 2280ns)
*	Writing 10000010110100010001100111100011  to  address 000000010 (from port 0) during cycle 114 (2280ns - 2300ns)
*	Reading 01001000011101111111111011001100 from address 111111011 (from port 0) during cycle 116 (2320ns - 2340ns)
*	Reading 01001000011101111111111011001100 from address 111111011 (from port 0) during cycle 117 (2340ns - 2360ns)
*	Writing 01000100110100100101000111001011  to  address 111111100 (from port 0) during cycle 118 (2360ns - 2380ns)
*	Reading 10001111100001010111001000111100 from address 000000000 (from port 0) during cycle 119 (2380ns - 2400ns)
*	Writing 11100001100110010001000001000000  to  address 111111101 (from port 0) during cycle 120 (2400ns - 2420ns)
*	Reading 10001111100001010111001000111100 from address 000000000 (from port 0) during cycle 122 (2440ns - 2460ns)
*	Writing 01010011001001001010100101010111  to  address 111111101 (from port 0) during cycle 123 (2460ns - 2480ns)
*	Reading 01000101001110111111111000011010 from address 111111110 (from port 0) during cycle 126 (2520ns - 2540ns)
*	Reading 01000101001110111111111000011010 from address 111111110 (from port 0) during cycle 129 (2580ns - 2600ns)
*	Writing 11110100110010001101000011101100  to  address 000000010 (from port 0) during cycle 131 (2620ns - 2640ns)
*	Reading 01000100110100100101000111001011 from address 111111100 (from port 0) during cycle 134 (2680ns - 2700ns)
*	Writing 10110110100110010010110001000100  to  address 111111110 (from port 0) during cycle 135 (2700ns - 2720ns)
*	Reading 10001111100001010111001000111100 from address 000000000 (from port 0) during cycle 136 (2720ns - 2740ns)
*	Reading 01000100110100100101000111001011 from address 111111100 (from port 0) during cycle 137 (2740ns - 2760ns)
*	Reading 01100111101010000010011110010010 from address 000000001 (from port 0) during cycle 138 (2760ns - 2780ns)
*	Reading 01001000011101111111111011001100 from address 111111011 (from port 0) during cycle 139 (2780ns - 2800ns)
*	Writing 01111011001111100110111111101101  to  address 000000001 (from port 0) during cycle 140 (2800ns - 2820ns)
*	Reading 11110100110010001101000011101100 from address 000000010 (from port 0) during cycle 141 (2820ns - 2840ns)
*	Reading 01111011001111100110111111101101 from address 000000001 (from port 0) during cycle 142 (2840ns - 2860ns)
*	Writing 01000110111010001110001100101001  to  address 000000001 (from port 0) during cycle 143 (2860ns - 2880ns)
*	Writing 10100100110001011001111100110000  to  address 111111101 (from port 0) during cycle 144 (2880ns - 2900ns)
*	Reading 10100100110001011001111100110000 from address 111111101 (from port 0) during cycle 146 (2920ns - 2940ns)
*	Reading 01001000011101111111111011001100 from address 111111011 (from port 0) during cycle 147 (2940ns - 2960ns)
*	Reading 10110110100110010010110001000100 from address 111111110 (from port 0) during cycle 148 (2960ns - 2980ns)
*	Writing 01100100011010011000100111110001  to  address 111111011 (from port 0) during cycle 149 (2980ns - 3000ns)
*	Reading 10100100110001011001111100110000 from address 111111101 (from port 0) during cycle 151 (3020ns - 3040ns)
*	Reading 10100100110001011001111100110000 from address 111111101 (from port 0) during cycle 152 (3040ns - 3060ns)
*	Writing 10011001011000010111011001001101  to  address 000000011 (from port 0) during cycle 153 (3060ns - 3080ns)
*	Writing 11100011000100111111001000111001  to  address 000000011 (from port 0) during cycle 154 (3080ns - 3100ns)
*	Reading 10001111100001010111001000111100 from address 000000000 (from port 0) during cycle 155 (3100ns - 3120ns)
*	Reading 11110100110010001101000011101100 from address 000000010 (from port 0) during cycle 158 (3160ns - 3180ns)
*	Reading 01000110111010001110001100101001 from address 000000001 (from port 0) during cycle 159 (3180ns - 3200ns)
*	Reading 01100100011010011000100111110001 from address 111111011 (from port 0) during cycle 161 (3220ns - 3240ns)
*	Reading 01000100110100100101000111001011 from address 111111100 (from port 0) during cycle 162 (3240ns - 3260ns)
*	Writing 00110011101111110110110110010101  to  address 111111100 (from port 0) during cycle 163 (3260ns - 3280ns)
*	Writing 01111101101001011100110000011011  to  address 000000000 (from port 0) during cycle 164 (3280ns - 3300ns)
*	Reading 01000110111010001110001100101001 from address 000000001 (from port 0) during cycle 165 (3300ns - 3320ns)
*	Reading 01100100011010011000100111110001 from address 111111011 (from port 0) during cycle 166 (3320ns - 3340ns)
*	Reading 01111101101001011100110000011011 from address 000000000 (from port 0) during cycle 168 (3360ns - 3380ns)
*	Reading 00110011101111110110110110010101 from address 111111100 (from port 0) during cycle 170 (3400ns - 3420ns)
*	Writing 00000011011111011110000001101100  to  address 000000011 (from port 0) during cycle 171 (3420ns - 3440ns)
*	Writing 11110010100001111101010111101101  to  address 111111110 (from port 0) during cycle 172 (3440ns - 3460ns)
*	Reading 01111101101001011100110000011011 from address 000000000 (from port 0) during cycle 175 (3500ns - 3520ns)
*	Reading 00000011011111011110000001101100 from address 000000011 (from port 0) during cycle 176 (3520ns - 3540ns)
*	Reading 01100100011010011000100111110001 from address 111111011 (from port 0) during cycle 177 (3540ns - 3560ns)
*	Reading 01000110111010001110001100101001 from address 000000001 (from port 0) during cycle 178 (3560ns - 3580ns)
*	Reading 01111101101001011100110000011011 from address 000000000 (from port 0) during cycle 180 (3600ns - 3620ns)
*	Writing 11101010111011010100011010110100  to  address 000000010 (from port 0) during cycle 184 (3680ns - 3700ns)
*	Reading 00110011101111110110110110010101 from address 111111100 (from port 0) during cycle 185 (3700ns - 3720ns)
*	Reading 01111101101001011100110000011011 from address 000000000 (from port 0) during cycle 186 (3720ns - 3740ns)
*	Writing 01100101101100110101011011110101  to  address 111111100 (from port 0) during cycle 187 (3740ns - 3760ns)
*	Writing 10011101111001110100101010011110  to  address 000000010 (from port 0) during cycle 189 (3780ns - 3800ns)
*	Reading 01111101101001011100110000011011 from address 000000000 (from port 0) during cycle 191 (3820ns - 3840ns)
*	Reading 01111101101001011100110000011011 from address 000000000 (from port 0) during cycle 192 (3840ns - 3860ns)
*	Reading 01100100011010011000100111110001 from address 111111011 (from port 0) during cycle 193 (3860ns - 3880ns)
*	Reading 01100101101100110101011011110101 from address 111111100 (from port 0) during cycle 194 (3880ns - 3900ns)
*	Writing 10100010101000011010011101110000  to  address 111111110 (from port 0) during cycle 195 (3900ns - 3920ns)
*	Writing 11001011100010110100111101011100  to  address 000000010 (from port 0) during cycle 196 (3920ns - 3940ns)
*	Reading 01111101101001011100110000011011 from address 000000000 (from port 0) during cycle 197 (3940ns - 3960ns)
*	Writing 00100000111100101111010101111101  to  address 111111100 (from port 0) during cycle 198 (3960ns - 3980ns)
*	Reading 00100000111100101111010101111101 from address 111111100 (from port 0) during cycle 199 (3980ns - 4000ns)
*	Writing 01111011001100000100011101011000  to  address 000000000 (from port 0) during cycle 200 (4000ns - 4020ns)
*	Writing 10011000001000100110010110101100  to  address 111111011 (from port 0) during cycle 202 (4040ns - 4060ns)
*	Writing 10110110011010000001110010110000  to  address 111111101 (from port 0) during cycle 203 (4060ns - 4080ns)
*	Idle during cycle 205 (4100ns - 4120ns)

* Generation of data and address signals
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 1), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 0), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 1), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 1), (3760, 1), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 0), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 0), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 1), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 1), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 1), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 1), (2820, 1), (2840, 1), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 1), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 1), (4020, 1), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 0), (460, 0), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 0), (960, 0), (980, 0), (1000, 0), (1020, 0), (1040, 0), (1060, 0), (1080, 0), (1100, 0), (1120, 0), (1140, 0), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 1), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 1), (1820, 1), (1840, 1), (1860, 1), (1880, 1), (1900, 1), (1920, 1), (1940, 1), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 1), (2400, 1), (2420, 1), (2440, 1), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 1), (2820, 1), (2840, 1), (2860, 1), (2880, 0), (2900, 0), (2920, 0), (2940, 0), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 1), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 1), (4020, 1), (4040, 0), (4060, 0), (4080, 0), (4100, 0)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 1.8v 1278.95n 1.8v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 1.8v 1818.95n 1.8v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 1.8v 3298.95n 1.8v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 1.8v 4018.95n 1.8v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 1), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 1), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 1), (1140, 1), (1160, 1), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 0), (1400, 1), (1420, 0), (1440, 0), (1460, 0), (1480, 0), (1500, 1), (1520, 1), (1540, 1), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 0), (1740, 0), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 1), (2020, 1), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 1), (2460, 0), (2480, 0), (2500, 0), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 1), (2640, 1), (2660, 1), (2680, 1), (2700, 1), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 0), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 0), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 1), (3700, 1), (3720, 1), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 1), (3920, 1), (3940, 1), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 1.8v 1178.95n 1.8v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 1.8v 2038.95n 1.8v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 1), (60, 1), (80, 1), (100, 0), (120, 0), (140, 0), (160, 1), (180, 1), (200, 1), (220, 1), (240, 0), (260, 1), (280, 1), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 1), (440, 1), (460, 1), (480, 1), (500, 1), (520, 1), (540, 0), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 0), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 1), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 1), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 1), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 1), (1860, 0), (1880, 1), (1900, 1), (1920, 1), (1940, 0), (1960, 0), (1980, 1), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 1), (2240, 1), (2260, 0), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 0), (2540, 0), (2560, 0), (2580, 0), (2600, 0), (2620, 0), (2640, 0), (2660, 0), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 1), (2780, 1), (2800, 1), (2820, 0), (2840, 1), (2860, 1), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 0), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 1), (3200, 1), (3220, 1), (3240, 0), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 0), (3460, 0), (3480, 0), (3500, 0), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_0  a0_0  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 1.8v 58.95n 1.8v 59.05n 1.8v 78.95n 1.8v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 1.8v 1898.95n 1.8v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 0.0v 2558.95n 0.0v 2559.05n 0.0v 2578.95n 0.0v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 0.0v 2618.95n 0.0v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 1.8v 2818.95n 1.8v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 1.8v 2878.95n 1.8v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 0.0v 3478.95n 0.0v 3479.05n 0.0v 3498.95n 0.0v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 1), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 0), (240, 0), (260, 0), (280, 0), (300, 0), (320, 0), (340, 1), (360, 1), (380, 0), (400, 0), (420, 1), (440, 1), (460, 1), (480, 0), (500, 0), (520, 1), (540, 0), (560, 0), (580, 0), (600, 1), (620, 1), (640, 1), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 0), (800, 0), (820, 0), (840, 1), (860, 1), (880, 1), (900, 1), (920, 0), (940, 0), (960, 1), (980, 1), (1000, 1), (1020, 0), (1040, 0), (1060, 1), (1080, 1), (1100, 0), (1120, 1), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 1), (1300, 0), (1320, 0), (1340, 0), (1360, 0), (1380, 1), (1400, 0), (1420, 1), (1440, 0), (1460, 0), (1480, 0), (1500, 0), (1520, 1), (1540, 0), (1560, 1), (1580, 0), (1600, 1), (1620, 0), (1640, 0), (1660, 0), (1680, 0), (1700, 0), (1720, 1), (1740, 1), (1760, 0), (1780, 0), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 1), (1940, 1), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 0), (2120, 0), (2140, 0), (2160, 0), (2180, 1), (2200, 1), (2220, 0), (2240, 1), (2260, 1), (2280, 1), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 0), (2400, 0), (2420, 0), (2440, 0), (2460, 0), (2480, 0), (2500, 0), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 1), (2640, 1), (2660, 1), (2680, 0), (2700, 1), (2720, 0), (2740, 0), (2760, 0), (2780, 1), (2800, 0), (2820, 1), (2840, 0), (2860, 0), (2880, 0), (2900, 0), (2920, 0), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 0), (3040, 0), (3060, 1), (3080, 1), (3100, 0), (3120, 0), (3140, 0), (3160, 1), (3180, 0), (3200, 0), (3220, 1), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 0), (3420, 1), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 1), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 1), (3700, 0), (3720, 0), (3740, 0), (3760, 0), (3780, 1), (3800, 1), (3820, 0), (3840, 0), (3860, 1), (3880, 0), (3900, 1), (3920, 1), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 0), (4040, 1), (4060, 0), (4080, 0), (4100, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 1.8v 38.95n 1.8v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 1.8v 438.95n 1.8v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 1.8v 538.95n 1.8v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 0.0v 798.95n 0.0v 799.05n 0.0v 818.95n 0.0v 819.05n 0.0v 838.95n 0.0v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 0.0v 1058.95n 0.0v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 1.8v 1138.95n 1.8v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 0.0v 1358.95n 0.0v 1359.05n 0.0v 1378.95n 0.0v 1379.05n 1.8v 1398.95n 1.8v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 1.8v 1438.95n 1.8v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 0.0v 1478.95n 0.0v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 0.0v 1698.95n 0.0v 1699.05n 0.0v 1718.95n 0.0v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 0.0v 1798.95n 0.0v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 0.0v 2138.95n 0.0v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 1.8v 2218.95n 1.8v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 1.8v 2298.95n 1.8v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 0.0v 2438.95n 0.0v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 0.0v 2498.95n 0.0v 2499.05n 0.0v 2518.95n 0.0v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 1.8v 2638.95n 1.8v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 0.0v 2918.95n 0.0v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 1.8v 3078.95n 1.8v 3079.05n 1.8v 3098.95n 1.8v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 1.8v 3438.95n 1.8v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 1.8v 3698.95n 1.8v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 0.0v 3778.95n 0.0v 3779.05n 1.8v 3798.95n 1.8v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 1.8v 3938.95n 1.8v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 0.0v 4098.95n 0.0v 4099.05n 0.0v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 0), (460, 0), (480, 1), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 0), (900, 0), (920, 0), (940, 1), (960, 0), (980, 0), (1000, 0), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 0), (1740, 0), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 0), (2340, 0), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 0), (2960, 1), (2980, 0), (3000, 0), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 0), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 0), (3340, 0), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 0), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 0), (4060, 1), (4080, 1), (4100, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 0.0v 478.95n 0.0v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 0.0v 898.95n 0.0v 899.05n 0.0v 918.95n 0.0v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 0.0v 978.95n 0.0v 979.05n 0.0v 998.95n 0.0v 999.05n 0.0v 1018.95n 0.0v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 0.0v 1758.95n 0.0v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 0.0v 3018.95n 0.0v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 0.0v 3358.95n 0.0v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_4  a0_4  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_5  a0_5  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_6  a0_6  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_7  a0_7  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 0), (20, 0), (40, 0), (60, 1), (80, 0), (100, 1), (120, 1), (140, 1), (160, 1), (180, 1), (200, 0), (220, 0), (240, 1), (260, 0), (280, 0), (300, 1), (320, 1), (340, 0), (360, 0), (380, 0), (400, 0), (420, 0), (440, 1), (460, 1), (480, 1), (500, 0), (520, 0), (540, 1), (560, 1), (580, 1), (600, 0), (620, 0), (640, 0), (660, 0), (680, 0), (700, 0), (720, 0), (740, 0), (760, 0), (780, 1), (800, 1), (820, 1), (840, 0), (860, 0), (880, 1), (900, 1), (920, 0), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 0), (1080, 0), (1100, 1), (1120, 0), (1140, 1), (1160, 0), (1180, 0), (1200, 0), (1220, 0), (1240, 1), (1260, 0), (1280, 0), (1300, 0), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 1), (1420, 0), (1440, 1), (1460, 1), (1480, 0), (1500, 1), (1520, 0), (1540, 1), (1560, 1), (1580, 1), (1600, 1), (1620, 1), (1640, 0), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 1), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 1), (1880, 0), (1900, 0), (1920, 1), (1940, 0), (1960, 1), (1980, 1), (2000, 1), (2020, 0), (2040, 0), (2060, 0), (2080, 0), (2100, 1), (2120, 1), (2140, 1), (2160, 1), (2180, 1), (2200, 0), (2220, 0), (2240, 0), (2260, 1), (2280, 0), (2300, 0), (2320, 1), (2340, 1), (2360, 1), (2380, 0), (2400, 1), (2420, 1), (2440, 0), (2460, 1), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 0), (2660, 0), (2680, 1), (2700, 1), (2720, 0), (2740, 1), (2760, 0), (2780, 1), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 1), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 1), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 0), (3120, 0), (3140, 0), (3160, 0), (3180, 0), (3200, 0), (3220, 1), (3240, 1), (3260, 1), (3280, 0), (3300, 0), (3320, 1), (3340, 1), (3360, 0), (3380, 0), (3400, 1), (3420, 0), (3440, 1), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 1), (3560, 0), (3580, 0), (3600, 0), (3620, 0), (3640, 0), (3660, 0), (3680, 0), (3700, 1), (3720, 0), (3740, 1), (3760, 1), (3780, 0), (3800, 0), (3820, 0), (3840, 0), (3860, 1), (3880, 1), (3900, 1), (3920, 0), (3940, 0), (3960, 1), (3980, 1), (4000, 0), (4020, 0), (4040, 1), (4060, 1), (4080, 1), (4100, 1)]
Va0_8  a0_8  0 PWL (0n 0.0v 18.95n 0.0v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 1.8v 78.95n 1.8v 79.05n 0.0v 98.95n 0.0v 99.05n 1.8v 118.95n 1.8v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 1.8v 198.95n 1.8v 199.05n 0.0v 218.95n 0.0v 219.05n 0.0v 238.95n 0.0v 239.05n 1.8v 258.95n 1.8v 259.05n 0.0v 278.95n 0.0v 279.05n 0.0v 298.95n 0.0v 299.05n 1.8v 318.95n 1.8v 319.05n 1.8v 338.95n 1.8v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 0.0v 418.95n 0.0v 419.05n 0.0v 438.95n 0.0v 439.05n 1.8v 458.95n 1.8v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 0.0v 658.95n 0.0v 659.05n 0.0v 678.95n 0.0v 679.05n 0.0v 698.95n 0.0v 699.05n 0.0v 718.95n 0.0v 719.05n 0.0v 738.95n 0.0v 739.05n 0.0v 758.95n 0.0v 759.05n 0.0v 778.95n 0.0v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 0.0v 858.95n 0.0v 859.05n 0.0v 878.95n 0.0v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 0.0v 1098.95n 0.0v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 1.8v 1158.95n 1.8v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 0.0v 1198.95n 0.0v 1199.05n 0.0v 1218.95n 0.0v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 1.8v 1418.95n 1.8v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 1.8v 1518.95n 1.8v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 1.8v 1578.95n 1.8v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 1.8v 1778.95n 1.8v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 1.8v 1978.95n 1.8v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 1.8v 2018.95n 1.8v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 0.0v 2078.95n 0.0v 2079.05n 0.0v 2098.95n 0.0v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 1.8v 2178.95n 1.8v 2179.05n 1.8v 2198.95n 1.8v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 0.0v 2318.95n 0.0v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 1.8v 2378.95n 1.8v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 1.8v 2418.95n 1.8v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 1.8v 2478.95n 1.8v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 0.0v 2658.95n 0.0v 2659.05n 0.0v 2678.95n 0.0v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 1.8v 2718.95n 1.8v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 1.8v 2898.95n 1.8v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 1.8v 2998.95n 1.8v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 0.0v 3138.95n 0.0v 3139.05n 0.0v 3158.95n 0.0v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 0.0v 3218.95n 0.0v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 1.8v 3278.95n 1.8v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 0.0v 3398.95n 0.0v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 1.8v 3458.95n 1.8v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 0.0v 3598.95n 0.0v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 0.0v 3638.95n 0.0v 3639.05n 0.0v 3658.95n 0.0v 3659.05n 0.0v 3678.95n 0.0v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 1.8v 3758.95n 1.8v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 0.0v 3818.95n 0.0v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 1.8v 3918.95n 1.8v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 1.8v 3978.95n 1.8v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 0.0v 4038.95n 0.0v 4039.05n 1.8v 4058.95n 1.8v 4059.05n 1.8v 4078.95n 1.8v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )

 * Generation of control signals
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 0), (100, 0), (120, 0), (140, 0), (160, 0), (180, 0), (200, 0), (220, 1), (240, 0), (260, 0), (280, 1), (300, 0), (320, 0), (340, 0), (360, 0), (380, 0), (400, 1), (420, 0), (440, 0), (460, 1), (480, 0), (500, 0), (520, 0), (540, 0), (560, 0), (580, 0), (600, 0), (620, 0), (640, 1), (660, 0), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 0), (800, 1), (820, 0), (840, 0), (860, 1), (880, 0), (900, 1), (920, 0), (940, 0), (960, 0), (980, 1), (1000, 0), (1020, 0), (1040, 1), (1060, 0), (1080, 1), (1100, 0), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 0), (1240, 0), (1260, 0), (1280, 0), (1300, 0), (1320, 0), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 0), (1460, 1), (1480, 0), (1500, 0), (1520, 0), (1540, 0), (1560, 0), (1580, 0), (1600, 0), (1620, 0), (1640, 0), (1660, 0), (1680, 1), (1700, 1), (1720, 0), (1740, 1), (1760, 0), (1780, 1), (1800, 0), (1820, 0), (1840, 0), (1860, 0), (1880, 0), (1900, 0), (1920, 0), (1940, 0), (1960, 0), (1980, 0), (2000, 0), (2020, 0), (2040, 0), (2060, 1), (2080, 1), (2100, 0), (2120, 1), (2140, 0), (2160, 0), (2180, 0), (2200, 0), (2220, 0), (2240, 0), (2260, 0), (2280, 0), (2300, 1), (2320, 0), (2340, 0), (2360, 0), (2380, 0), (2400, 0), (2420, 1), (2440, 0), (2460, 0), (2480, 1), (2500, 1), (2520, 0), (2540, 1), (2560, 1), (2580, 0), (2600, 1), (2620, 0), (2640, 1), (2660, 1), (2680, 0), (2700, 0), (2720, 0), (2740, 0), (2760, 0), (2780, 0), (2800, 0), (2820, 0), (2840, 0), (2860, 0), (2880, 0), (2900, 1), (2920, 0), (2940, 0), (2960, 0), (2980, 0), (3000, 1), (3020, 0), (3040, 0), (3060, 0), (3080, 0), (3100, 0), (3120, 1), (3140, 1), (3160, 0), (3180, 0), (3200, 1), (3220, 0), (3240, 0), (3260, 0), (3280, 0), (3300, 0), (3320, 0), (3340, 1), (3360, 0), (3380, 1), (3400, 0), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 0), (3520, 0), (3540, 0), (3560, 0), (3580, 1), (3600, 0), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 0), (3720, 0), (3740, 0), (3760, 1), (3780, 0), (3800, 1), (3820, 0), (3840, 0), (3860, 0), (3880, 0), (3900, 0), (3920, 0), (3940, 0), (3960, 0), (3980, 0), (4000, 0), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
VCSB0 CSB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 0.0v 98.95n 0.0v 99.05n 0.0v 118.95n 0.0v 119.05n 0.0v 138.95n 0.0v 139.05n 0.0v 158.95n 0.0v 159.05n 0.0v 178.95n 0.0v 179.05n 0.0v 198.95n 0.0v 199.05n 0.0v 218.95n 0.0v 219.05n 1.8v 238.95n 1.8v 239.05n 0.0v 258.95n 0.0v 259.05n 0.0v 278.95n 0.0v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 0.0v 338.95n 0.0v 339.05n 0.0v 358.95n 0.0v 359.05n 0.0v 378.95n 0.0v 379.05n 0.0v 398.95n 0.0v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 0.0v 498.95n 0.0v 499.05n 0.0v 518.95n 0.0v 519.05n 0.0v 538.95n 0.0v 539.05n 0.0v 558.95n 0.0v 559.05n 0.0v 578.95n 0.0v 579.05n 0.0v 598.95n 0.0v 599.05n 0.0v 618.95n 0.0v 619.05n 0.0v 638.95n 0.0v 639.05n 1.8v 658.95n 1.8v 659.05n 0.0v 678.95n 0.0v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 0.0v 798.95n 0.0v 799.05n 1.8v 818.95n 1.8v 819.05n 0.0v 838.95n 0.0v 839.05n 0.0v 858.95n 0.0v 859.05n 1.8v 878.95n 1.8v 879.05n 0.0v 898.95n 0.0v 899.05n 1.8v 918.95n 1.8v 919.05n 0.0v 938.95n 0.0v 939.05n 0.0v 958.95n 0.0v 959.05n 0.0v 978.95n 0.0v 979.05n 1.8v 998.95n 1.8v 999.05n 0.0v 1018.95n 0.0v 1019.05n 0.0v 1038.95n 0.0v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 0.0v 1078.95n 0.0v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 0.0v 1118.95n 0.0v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 0.0v 1238.95n 0.0v 1239.05n 0.0v 1258.95n 0.0v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 0.0v 1298.95n 0.0v 1299.05n 0.0v 1318.95n 0.0v 1319.05n 0.0v 1338.95n 0.0v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 0.0v 1458.95n 0.0v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 0.0v 1498.95n 0.0v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 0.0v 1538.95n 0.0v 1539.05n 0.0v 1558.95n 0.0v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 0.0v 1598.95n 0.0v 1599.05n 0.0v 1618.95n 0.0v 1619.05n 0.0v 1638.95n 0.0v 1639.05n 0.0v 1658.95n 0.0v 1659.05n 0.0v 1678.95n 0.0v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 0.0v 1738.95n 0.0v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 0.0v 1838.95n 0.0v 1839.05n 0.0v 1858.95n 0.0v 1859.05n 0.0v 1878.95n 0.0v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 0.0v 1918.95n 0.0v 1919.05n 0.0v 1938.95n 0.0v 1939.05n 0.0v 1958.95n 0.0v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 0.0v 1998.95n 0.0v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 0.0v 2058.95n 0.0v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 0.0v 2118.95n 0.0v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 0.0v 2158.95n 0.0v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 0.0v 2238.95n 0.0v 2239.05n 0.0v 2258.95n 0.0v 2259.05n 0.0v 2278.95n 0.0v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 0.0v 2338.95n 0.0v 2339.05n 0.0v 2358.95n 0.0v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 0.0v 2398.95n 0.0v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 0.0v 2458.95n 0.0v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 0.0v 2538.95n 0.0v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 0.0v 2598.95n 0.0v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 0.0v 2698.95n 0.0v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 0.0v 2738.95n 0.0v 2739.05n 0.0v 2758.95n 0.0v 2759.05n 0.0v 2778.95n 0.0v 2779.05n 0.0v 2798.95n 0.0v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 0.0v 2838.95n 0.0v 2839.05n 0.0v 2858.95n 0.0v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 0.0v 2938.95n 0.0v 2939.05n 0.0v 2958.95n 0.0v 2959.05n 0.0v 2978.95n 0.0v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 0.0v 3038.95n 0.0v 3039.05n 0.0v 3058.95n 0.0v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 0.0v 3118.95n 0.0v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 0.0v 3178.95n 0.0v 3179.05n 0.0v 3198.95n 0.0v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 0.0v 3238.95n 0.0v 3239.05n 0.0v 3258.95n 0.0v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 0.0v 3318.95n 0.0v 3319.05n 0.0v 3338.95n 0.0v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 0.0v 3378.95n 0.0v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 0.0v 3418.95n 0.0v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 0.0v 3518.95n 0.0v 3519.05n 0.0v 3538.95n 0.0v 3539.05n 0.0v 3558.95n 0.0v 3559.05n 0.0v 3578.95n 0.0v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 0.0v 3618.95n 0.0v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 0.0v 3718.95n 0.0v 3719.05n 0.0v 3738.95n 0.0v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 0.0v 3838.95n 0.0v 3839.05n 0.0v 3858.95n 0.0v 3859.05n 0.0v 3878.95n 0.0v 3879.05n 0.0v 3898.95n 0.0v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 0.0v 3958.95n 0.0v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 0.0v 3998.95n 0.0v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* (time, data): [(0, 1), (20, 0), (40, 0), (60, 0), (80, 1), (100, 0), (120, 1), (140, 1), (160, 1), (180, 0), (200, 1), (220, 1), (240, 1), (260, 1), (280, 1), (300, 0), (320, 1), (340, 1), (360, 1), (380, 1), (400, 1), (420, 0), (440, 0), (460, 1), (480, 1), (500, 1), (520, 1), (540, 1), (560, 1), (580, 1), (600, 1), (620, 1), (640, 1), (660, 1), (680, 1), (700, 1), (720, 1), (740, 1), (760, 1), (780, 1), (800, 1), (820, 1), (840, 1), (860, 1), (880, 1), (900, 1), (920, 1), (940, 1), (960, 1), (980, 1), (1000, 1), (1020, 1), (1040, 1), (1060, 1), (1080, 1), (1100, 1), (1120, 0), (1140, 0), (1160, 0), (1180, 1), (1200, 1), (1220, 1), (1240, 1), (1260, 0), (1280, 1), (1300, 1), (1320, 1), (1340, 1), (1360, 1), (1380, 0), (1400, 0), (1420, 0), (1440, 1), (1460, 1), (1480, 1), (1500, 0), (1520, 1), (1540, 1), (1560, 0), (1580, 1), (1600, 1), (1620, 1), (1640, 1), (1660, 1), (1680, 1), (1700, 1), (1720, 1), (1740, 1), (1760, 0), (1780, 1), (1800, 0), (1820, 1), (1840, 1), (1860, 1), (1880, 0), (1900, 1), (1920, 1), (1940, 1), (1960, 0), (1980, 1), (2000, 0), (2020, 0), (2040, 1), (2060, 1), (2080, 1), (2100, 1), (2120, 1), (2140, 1), (2160, 0), (2180, 0), (2200, 0), (2220, 1), (2240, 1), (2260, 1), (2280, 0), (2300, 1), (2320, 1), (2340, 1), (2360, 0), (2380, 1), (2400, 0), (2420, 1), (2440, 1), (2460, 0), (2480, 1), (2500, 1), (2520, 1), (2540, 1), (2560, 1), (2580, 1), (2600, 1), (2620, 0), (2640, 1), (2660, 1), (2680, 1), (2700, 0), (2720, 1), (2740, 1), (2760, 1), (2780, 1), (2800, 0), (2820, 1), (2840, 1), (2860, 0), (2880, 0), (2900, 1), (2920, 1), (2940, 1), (2960, 1), (2980, 0), (3000, 1), (3020, 1), (3040, 1), (3060, 0), (3080, 0), (3100, 1), (3120, 1), (3140, 1), (3160, 1), (3180, 1), (3200, 1), (3220, 1), (3240, 1), (3260, 0), (3280, 0), (3300, 1), (3320, 1), (3340, 1), (3360, 1), (3380, 1), (3400, 1), (3420, 0), (3440, 0), (3460, 1), (3480, 1), (3500, 1), (3520, 1), (3540, 1), (3560, 1), (3580, 1), (3600, 1), (3620, 1), (3640, 1), (3660, 1), (3680, 0), (3700, 1), (3720, 1), (3740, 0), (3760, 1), (3780, 0), (3800, 1), (3820, 1), (3840, 1), (3860, 1), (3880, 1), (3900, 0), (3920, 0), (3940, 1), (3960, 0), (3980, 1), (4000, 0), (4020, 1), (4040, 0), (4060, 0), (4080, 1), (4100, 1)]
VWEB0 WEB0 0 PWL (0n 1.8v 18.95n 1.8v 19.05n 0.0v 38.95n 0.0v 39.05n 0.0v 58.95n 0.0v 59.05n 0.0v 78.95n 0.0v 79.05n 1.8v 98.95n 1.8v 99.05n 0.0v 118.95n 0.0v 119.05n 1.8v 138.95n 1.8v 139.05n 1.8v 158.95n 1.8v 159.05n 1.8v 178.95n 1.8v 179.05n 0.0v 198.95n 0.0v 199.05n 1.8v 218.95n 1.8v 219.05n 1.8v 238.95n 1.8v 239.05n 1.8v 258.95n 1.8v 259.05n 1.8v 278.95n 1.8v 279.05n 1.8v 298.95n 1.8v 299.05n 0.0v 318.95n 0.0v 319.05n 1.8v 338.95n 1.8v 339.05n 1.8v 358.95n 1.8v 359.05n 1.8v 378.95n 1.8v 379.05n 1.8v 398.95n 1.8v 399.05n 1.8v 418.95n 1.8v 419.05n 0.0v 438.95n 0.0v 439.05n 0.0v 458.95n 0.0v 459.05n 1.8v 478.95n 1.8v 479.05n 1.8v 498.95n 1.8v 499.05n 1.8v 518.95n 1.8v 519.05n 1.8v 538.95n 1.8v 539.05n 1.8v 558.95n 1.8v 559.05n 1.8v 578.95n 1.8v 579.05n 1.8v 598.95n 1.8v 599.05n 1.8v 618.95n 1.8v 619.05n 1.8v 638.95n 1.8v 639.05n 1.8v 658.95n 1.8v 659.05n 1.8v 678.95n 1.8v 679.05n 1.8v 698.95n 1.8v 699.05n 1.8v 718.95n 1.8v 719.05n 1.8v 738.95n 1.8v 739.05n 1.8v 758.95n 1.8v 759.05n 1.8v 778.95n 1.8v 779.05n 1.8v 798.95n 1.8v 799.05n 1.8v 818.95n 1.8v 819.05n 1.8v 838.95n 1.8v 839.05n 1.8v 858.95n 1.8v 859.05n 1.8v 878.95n 1.8v 879.05n 1.8v 898.95n 1.8v 899.05n 1.8v 918.95n 1.8v 919.05n 1.8v 938.95n 1.8v 939.05n 1.8v 958.95n 1.8v 959.05n 1.8v 978.95n 1.8v 979.05n 1.8v 998.95n 1.8v 999.05n 1.8v 1018.95n 1.8v 1019.05n 1.8v 1038.95n 1.8v 1039.05n 1.8v 1058.95n 1.8v 1059.05n 1.8v 1078.95n 1.8v 1079.05n 1.8v 1098.95n 1.8v 1099.05n 1.8v 1118.95n 1.8v 1119.05n 0.0v 1138.95n 0.0v 1139.05n 0.0v 1158.95n 0.0v 1159.05n 0.0v 1178.95n 0.0v 1179.05n 1.8v 1198.95n 1.8v 1199.05n 1.8v 1218.95n 1.8v 1219.05n 1.8v 1238.95n 1.8v 1239.05n 1.8v 1258.95n 1.8v 1259.05n 0.0v 1278.95n 0.0v 1279.05n 1.8v 1298.95n 1.8v 1299.05n 1.8v 1318.95n 1.8v 1319.05n 1.8v 1338.95n 1.8v 1339.05n 1.8v 1358.95n 1.8v 1359.05n 1.8v 1378.95n 1.8v 1379.05n 0.0v 1398.95n 0.0v 1399.05n 0.0v 1418.95n 0.0v 1419.05n 0.0v 1438.95n 0.0v 1439.05n 1.8v 1458.95n 1.8v 1459.05n 1.8v 1478.95n 1.8v 1479.05n 1.8v 1498.95n 1.8v 1499.05n 0.0v 1518.95n 0.0v 1519.05n 1.8v 1538.95n 1.8v 1539.05n 1.8v 1558.95n 1.8v 1559.05n 0.0v 1578.95n 0.0v 1579.05n 1.8v 1598.95n 1.8v 1599.05n 1.8v 1618.95n 1.8v 1619.05n 1.8v 1638.95n 1.8v 1639.05n 1.8v 1658.95n 1.8v 1659.05n 1.8v 1678.95n 1.8v 1679.05n 1.8v 1698.95n 1.8v 1699.05n 1.8v 1718.95n 1.8v 1719.05n 1.8v 1738.95n 1.8v 1739.05n 1.8v 1758.95n 1.8v 1759.05n 0.0v 1778.95n 0.0v 1779.05n 1.8v 1798.95n 1.8v 1799.05n 0.0v 1818.95n 0.0v 1819.05n 1.8v 1838.95n 1.8v 1839.05n 1.8v 1858.95n 1.8v 1859.05n 1.8v 1878.95n 1.8v 1879.05n 0.0v 1898.95n 0.0v 1899.05n 1.8v 1918.95n 1.8v 1919.05n 1.8v 1938.95n 1.8v 1939.05n 1.8v 1958.95n 1.8v 1959.05n 0.0v 1978.95n 0.0v 1979.05n 1.8v 1998.95n 1.8v 1999.05n 0.0v 2018.95n 0.0v 2019.05n 0.0v 2038.95n 0.0v 2039.05n 1.8v 2058.95n 1.8v 2059.05n 1.8v 2078.95n 1.8v 2079.05n 1.8v 2098.95n 1.8v 2099.05n 1.8v 2118.95n 1.8v 2119.05n 1.8v 2138.95n 1.8v 2139.05n 1.8v 2158.95n 1.8v 2159.05n 0.0v 2178.95n 0.0v 2179.05n 0.0v 2198.95n 0.0v 2199.05n 0.0v 2218.95n 0.0v 2219.05n 1.8v 2238.95n 1.8v 2239.05n 1.8v 2258.95n 1.8v 2259.05n 1.8v 2278.95n 1.8v 2279.05n 0.0v 2298.95n 0.0v 2299.05n 1.8v 2318.95n 1.8v 2319.05n 1.8v 2338.95n 1.8v 2339.05n 1.8v 2358.95n 1.8v 2359.05n 0.0v 2378.95n 0.0v 2379.05n 1.8v 2398.95n 1.8v 2399.05n 0.0v 2418.95n 0.0v 2419.05n 1.8v 2438.95n 1.8v 2439.05n 1.8v 2458.95n 1.8v 2459.05n 0.0v 2478.95n 0.0v 2479.05n 1.8v 2498.95n 1.8v 2499.05n 1.8v 2518.95n 1.8v 2519.05n 1.8v 2538.95n 1.8v 2539.05n 1.8v 2558.95n 1.8v 2559.05n 1.8v 2578.95n 1.8v 2579.05n 1.8v 2598.95n 1.8v 2599.05n 1.8v 2618.95n 1.8v 2619.05n 0.0v 2638.95n 0.0v 2639.05n 1.8v 2658.95n 1.8v 2659.05n 1.8v 2678.95n 1.8v 2679.05n 1.8v 2698.95n 1.8v 2699.05n 0.0v 2718.95n 0.0v 2719.05n 1.8v 2738.95n 1.8v 2739.05n 1.8v 2758.95n 1.8v 2759.05n 1.8v 2778.95n 1.8v 2779.05n 1.8v 2798.95n 1.8v 2799.05n 0.0v 2818.95n 0.0v 2819.05n 1.8v 2838.95n 1.8v 2839.05n 1.8v 2858.95n 1.8v 2859.05n 0.0v 2878.95n 0.0v 2879.05n 0.0v 2898.95n 0.0v 2899.05n 1.8v 2918.95n 1.8v 2919.05n 1.8v 2938.95n 1.8v 2939.05n 1.8v 2958.95n 1.8v 2959.05n 1.8v 2978.95n 1.8v 2979.05n 0.0v 2998.95n 0.0v 2999.05n 1.8v 3018.95n 1.8v 3019.05n 1.8v 3038.95n 1.8v 3039.05n 1.8v 3058.95n 1.8v 3059.05n 0.0v 3078.95n 0.0v 3079.05n 0.0v 3098.95n 0.0v 3099.05n 1.8v 3118.95n 1.8v 3119.05n 1.8v 3138.95n 1.8v 3139.05n 1.8v 3158.95n 1.8v 3159.05n 1.8v 3178.95n 1.8v 3179.05n 1.8v 3198.95n 1.8v 3199.05n 1.8v 3218.95n 1.8v 3219.05n 1.8v 3238.95n 1.8v 3239.05n 1.8v 3258.95n 1.8v 3259.05n 0.0v 3278.95n 0.0v 3279.05n 0.0v 3298.95n 0.0v 3299.05n 1.8v 3318.95n 1.8v 3319.05n 1.8v 3338.95n 1.8v 3339.05n 1.8v 3358.95n 1.8v 3359.05n 1.8v 3378.95n 1.8v 3379.05n 1.8v 3398.95n 1.8v 3399.05n 1.8v 3418.95n 1.8v 3419.05n 0.0v 3438.95n 0.0v 3439.05n 0.0v 3458.95n 0.0v 3459.05n 1.8v 3478.95n 1.8v 3479.05n 1.8v 3498.95n 1.8v 3499.05n 1.8v 3518.95n 1.8v 3519.05n 1.8v 3538.95n 1.8v 3539.05n 1.8v 3558.95n 1.8v 3559.05n 1.8v 3578.95n 1.8v 3579.05n 1.8v 3598.95n 1.8v 3599.05n 1.8v 3618.95n 1.8v 3619.05n 1.8v 3638.95n 1.8v 3639.05n 1.8v 3658.95n 1.8v 3659.05n 1.8v 3678.95n 1.8v 3679.05n 0.0v 3698.95n 0.0v 3699.05n 1.8v 3718.95n 1.8v 3719.05n 1.8v 3738.95n 1.8v 3739.05n 0.0v 3758.95n 0.0v 3759.05n 1.8v 3778.95n 1.8v 3779.05n 0.0v 3798.95n 0.0v 3799.05n 1.8v 3818.95n 1.8v 3819.05n 1.8v 3838.95n 1.8v 3839.05n 1.8v 3858.95n 1.8v 3859.05n 1.8v 3878.95n 1.8v 3879.05n 1.8v 3898.95n 1.8v 3899.05n 0.0v 3918.95n 0.0v 3919.05n 0.0v 3938.95n 0.0v 3939.05n 1.8v 3958.95n 1.8v 3959.05n 0.0v 3978.95n 0.0v 3979.05n 1.8v 3998.95n 1.8v 3999.05n 0.0v 4018.95n 0.0v 4019.05n 1.8v 4038.95n 1.8v 4039.05n 0.0v 4058.95n 0.0v 4059.05n 0.0v 4078.95n 0.0v 4079.05n 1.8v 4098.95n 1.8v 4099.05n 1.8v )
* PULSE: period=20
Vclk0 clk0 0 PULSE (0 1.8 19.95n 0.1n 0.1n 9.899999999999999n 20n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 100
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=100.1n

* CHECK dout0_1 Vdout0_1ck4 = 1.8 time = 100
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=100.1n

* CHECK dout0_2 Vdout0_2ck4 = 1.8 time = 100
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=100.1n

* CHECK dout0_3 Vdout0_3ck4 = 1.8 time = 100
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=100.1n

* CHECK dout0_4 Vdout0_4ck4 = 0 time = 100
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=100.1n

* CHECK dout0_5 Vdout0_5ck4 = 1.8 time = 100
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=100.1n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 100
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=100.1n

* CHECK dout0_7 Vdout0_7ck4 = 1.8 time = 100
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=100.1n

* CHECK dout0_8 Vdout0_8ck4 = 0 time = 100
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=100.1n

* CHECK dout0_9 Vdout0_9ck4 = 1.8 time = 100
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=100.1n

* CHECK dout0_10 Vdout0_10ck4 = 1.8 time = 100
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=100.1n

* CHECK dout0_11 Vdout0_11ck4 = 1.8 time = 100
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=100.1n

* CHECK dout0_12 Vdout0_12ck4 = 0 time = 100
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=100.1n

* CHECK dout0_13 Vdout0_13ck4 = 0 time = 100
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=100.1n

* CHECK dout0_14 Vdout0_14ck4 = 0 time = 100
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=100.1n

* CHECK dout0_15 Vdout0_15ck4 = 0 time = 100
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=100.1n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 100
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=100.1n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 100
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=100.1n

* CHECK dout0_18 Vdout0_18ck4 = 0 time = 100
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=100.1n

* CHECK dout0_19 Vdout0_19ck4 = 0 time = 100
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=100.1n

* CHECK dout0_20 Vdout0_20ck4 = 1.8 time = 100
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=100.1n

* CHECK dout0_21 Vdout0_21ck4 = 1.8 time = 100
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=100.1n

* CHECK dout0_22 Vdout0_22ck4 = 0 time = 100
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=100.1n

* CHECK dout0_23 Vdout0_23ck4 = 1.8 time = 100
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=100.1n

* CHECK dout0_24 Vdout0_24ck4 = 1.8 time = 100
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=100.1n

* CHECK dout0_25 Vdout0_25ck4 = 0 time = 100
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=100.1n

* CHECK dout0_26 Vdout0_26ck4 = 0 time = 100
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=100.1n

* CHECK dout0_27 Vdout0_27ck4 = 0 time = 100
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=100.1n

* CHECK dout0_28 Vdout0_28ck4 = 1.8 time = 100
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=100.1n

* CHECK dout0_29 Vdout0_29ck4 = 0 time = 100
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=100.1n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 100
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=100.1n

* CHECK dout0_31 Vdout0_31ck4 = 1.8 time = 100
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=100.1n

* CHECK dout0_0 Vdout0_0ck6 = 1.8 time = 140
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=140.1n

* CHECK dout0_1 Vdout0_1ck6 = 1.8 time = 140
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=140.1n

* CHECK dout0_2 Vdout0_2ck6 = 0 time = 140
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=140.1n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 140
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=140.1n

* CHECK dout0_4 Vdout0_4ck6 = 0 time = 140
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=140.1n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 140
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=140.1n

* CHECK dout0_6 Vdout0_6ck6 = 0 time = 140
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=140.1n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 140
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=140.1n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 140
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=140.1n

* CHECK dout0_9 Vdout0_9ck6 = 1.8 time = 140
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=140.1n

* CHECK dout0_10 Vdout0_10ck6 = 1.8 time = 140
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=140.1n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 140
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=140.1n

* CHECK dout0_12 Vdout0_12ck6 = 1.8 time = 140
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=140.1n

* CHECK dout0_13 Vdout0_13ck6 = 1.8 time = 140
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=140.1n

* CHECK dout0_14 Vdout0_14ck6 = 1.8 time = 140
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=140.1n

* CHECK dout0_15 Vdout0_15ck6 = 0 time = 140
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=140.1n

* CHECK dout0_16 Vdout0_16ck6 = 0 time = 140
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=140.1n

* CHECK dout0_17 Vdout0_17ck6 = 1.8 time = 140
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=140.1n

* CHECK dout0_18 Vdout0_18ck6 = 0 time = 140
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=140.1n

* CHECK dout0_19 Vdout0_19ck6 = 1.8 time = 140
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=140.1n

* CHECK dout0_20 Vdout0_20ck6 = 0 time = 140
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=140.1n

* CHECK dout0_21 Vdout0_21ck6 = 1.8 time = 140
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=140.1n

* CHECK dout0_22 Vdout0_22ck6 = 1.8 time = 140
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=140.1n

* CHECK dout0_23 Vdout0_23ck6 = 1.8 time = 140
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=140.1n

* CHECK dout0_24 Vdout0_24ck6 = 0 time = 140
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=140.1n

* CHECK dout0_25 Vdout0_25ck6 = 0 time = 140
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=140.1n

* CHECK dout0_26 Vdout0_26ck6 = 1.8 time = 140
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=140.1n

* CHECK dout0_27 Vdout0_27ck6 = 1.8 time = 140
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=140.1n

* CHECK dout0_28 Vdout0_28ck6 = 0 time = 140
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=140.1n

* CHECK dout0_29 Vdout0_29ck6 = 1.8 time = 140
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=140.1n

* CHECK dout0_30 Vdout0_30ck6 = 1.8 time = 140
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=140.1n

* CHECK dout0_31 Vdout0_31ck6 = 0 time = 140
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=140.1n

* CHECK dout0_0 Vdout0_0ck7 = 1.8 time = 160
.meas tran vdout0_0ck7 FIND v(dout0_0) AT=160.1n

* CHECK dout0_1 Vdout0_1ck7 = 1.8 time = 160
.meas tran vdout0_1ck7 FIND v(dout0_1) AT=160.1n

* CHECK dout0_2 Vdout0_2ck7 = 0 time = 160
.meas tran vdout0_2ck7 FIND v(dout0_2) AT=160.1n

* CHECK dout0_3 Vdout0_3ck7 = 0 time = 160
.meas tran vdout0_3ck7 FIND v(dout0_3) AT=160.1n

* CHECK dout0_4 Vdout0_4ck7 = 0 time = 160
.meas tran vdout0_4ck7 FIND v(dout0_4) AT=160.1n

* CHECK dout0_5 Vdout0_5ck7 = 0 time = 160
.meas tran vdout0_5ck7 FIND v(dout0_5) AT=160.1n

* CHECK dout0_6 Vdout0_6ck7 = 0 time = 160
.meas tran vdout0_6ck7 FIND v(dout0_6) AT=160.1n

* CHECK dout0_7 Vdout0_7ck7 = 0 time = 160
.meas tran vdout0_7ck7 FIND v(dout0_7) AT=160.1n

* CHECK dout0_8 Vdout0_8ck7 = 0 time = 160
.meas tran vdout0_8ck7 FIND v(dout0_8) AT=160.1n

* CHECK dout0_9 Vdout0_9ck7 = 1.8 time = 160
.meas tran vdout0_9ck7 FIND v(dout0_9) AT=160.1n

* CHECK dout0_10 Vdout0_10ck7 = 1.8 time = 160
.meas tran vdout0_10ck7 FIND v(dout0_10) AT=160.1n

* CHECK dout0_11 Vdout0_11ck7 = 0 time = 160
.meas tran vdout0_11ck7 FIND v(dout0_11) AT=160.1n

* CHECK dout0_12 Vdout0_12ck7 = 1.8 time = 160
.meas tran vdout0_12ck7 FIND v(dout0_12) AT=160.1n

* CHECK dout0_13 Vdout0_13ck7 = 1.8 time = 160
.meas tran vdout0_13ck7 FIND v(dout0_13) AT=160.1n

* CHECK dout0_14 Vdout0_14ck7 = 1.8 time = 160
.meas tran vdout0_14ck7 FIND v(dout0_14) AT=160.1n

* CHECK dout0_15 Vdout0_15ck7 = 0 time = 160
.meas tran vdout0_15ck7 FIND v(dout0_15) AT=160.1n

* CHECK dout0_16 Vdout0_16ck7 = 0 time = 160
.meas tran vdout0_16ck7 FIND v(dout0_16) AT=160.1n

* CHECK dout0_17 Vdout0_17ck7 = 1.8 time = 160
.meas tran vdout0_17ck7 FIND v(dout0_17) AT=160.1n

* CHECK dout0_18 Vdout0_18ck7 = 0 time = 160
.meas tran vdout0_18ck7 FIND v(dout0_18) AT=160.1n

* CHECK dout0_19 Vdout0_19ck7 = 1.8 time = 160
.meas tran vdout0_19ck7 FIND v(dout0_19) AT=160.1n

* CHECK dout0_20 Vdout0_20ck7 = 0 time = 160
.meas tran vdout0_20ck7 FIND v(dout0_20) AT=160.1n

* CHECK dout0_21 Vdout0_21ck7 = 1.8 time = 160
.meas tran vdout0_21ck7 FIND v(dout0_21) AT=160.1n

* CHECK dout0_22 Vdout0_22ck7 = 1.8 time = 160
.meas tran vdout0_22ck7 FIND v(dout0_22) AT=160.1n

* CHECK dout0_23 Vdout0_23ck7 = 1.8 time = 160
.meas tran vdout0_23ck7 FIND v(dout0_23) AT=160.1n

* CHECK dout0_24 Vdout0_24ck7 = 0 time = 160
.meas tran vdout0_24ck7 FIND v(dout0_24) AT=160.1n

* CHECK dout0_25 Vdout0_25ck7 = 0 time = 160
.meas tran vdout0_25ck7 FIND v(dout0_25) AT=160.1n

* CHECK dout0_26 Vdout0_26ck7 = 1.8 time = 160
.meas tran vdout0_26ck7 FIND v(dout0_26) AT=160.1n

* CHECK dout0_27 Vdout0_27ck7 = 1.8 time = 160
.meas tran vdout0_27ck7 FIND v(dout0_27) AT=160.1n

* CHECK dout0_28 Vdout0_28ck7 = 0 time = 160
.meas tran vdout0_28ck7 FIND v(dout0_28) AT=160.1n

* CHECK dout0_29 Vdout0_29ck7 = 1.8 time = 160
.meas tran vdout0_29ck7 FIND v(dout0_29) AT=160.1n

* CHECK dout0_30 Vdout0_30ck7 = 1.8 time = 160
.meas tran vdout0_30ck7 FIND v(dout0_30) AT=160.1n

* CHECK dout0_31 Vdout0_31ck7 = 0 time = 160
.meas tran vdout0_31ck7 FIND v(dout0_31) AT=160.1n

* CHECK dout0_0 Vdout0_0ck8 = 0 time = 180
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=180.1n

* CHECK dout0_1 Vdout0_1ck8 = 0 time = 180
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=180.1n

* CHECK dout0_2 Vdout0_2ck8 = 1.8 time = 180
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=180.1n

* CHECK dout0_3 Vdout0_3ck8 = 0 time = 180
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=180.1n

* CHECK dout0_4 Vdout0_4ck8 = 1.8 time = 180
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=180.1n

* CHECK dout0_5 Vdout0_5ck8 = 0 time = 180
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=180.1n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 180
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=180.1n

* CHECK dout0_7 Vdout0_7ck8 = 1.8 time = 180
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=180.1n

* CHECK dout0_8 Vdout0_8ck8 = 0 time = 180
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=180.1n

* CHECK dout0_9 Vdout0_9ck8 = 0 time = 180
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=180.1n

* CHECK dout0_10 Vdout0_10ck8 = 0 time = 180
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=180.1n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 180
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=180.1n

* CHECK dout0_12 Vdout0_12ck8 = 1.8 time = 180
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=180.1n

* CHECK dout0_13 Vdout0_13ck8 = 0 time = 180
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=180.1n

* CHECK dout0_14 Vdout0_14ck8 = 1.8 time = 180
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=180.1n

* CHECK dout0_15 Vdout0_15ck8 = 0 time = 180
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=180.1n

* CHECK dout0_16 Vdout0_16ck8 = 1.8 time = 180
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=180.1n

* CHECK dout0_17 Vdout0_17ck8 = 0 time = 180
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=180.1n

* CHECK dout0_18 Vdout0_18ck8 = 0 time = 180
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=180.1n

* CHECK dout0_19 Vdout0_19ck8 = 1.8 time = 180
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=180.1n

* CHECK dout0_20 Vdout0_20ck8 = 0 time = 180
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=180.1n

* CHECK dout0_21 Vdout0_21ck8 = 0 time = 180
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=180.1n

* CHECK dout0_22 Vdout0_22ck8 = 0 time = 180
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=180.1n

* CHECK dout0_23 Vdout0_23ck8 = 0 time = 180
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=180.1n

* CHECK dout0_24 Vdout0_24ck8 = 0 time = 180
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=180.1n

* CHECK dout0_25 Vdout0_25ck8 = 0 time = 180
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=180.1n

* CHECK dout0_26 Vdout0_26ck8 = 0 time = 180
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=180.1n

* CHECK dout0_27 Vdout0_27ck8 = 0 time = 180
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=180.1n

* CHECK dout0_28 Vdout0_28ck8 = 1.8 time = 180
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=180.1n

* CHECK dout0_29 Vdout0_29ck8 = 1.8 time = 180
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=180.1n

* CHECK dout0_30 Vdout0_30ck8 = 0 time = 180
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=180.1n

* CHECK dout0_31 Vdout0_31ck8 = 0 time = 180
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=180.1n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 220
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=220.1n

* CHECK dout0_1 Vdout0_1ck10 = 1.8 time = 220
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=220.1n

* CHECK dout0_2 Vdout0_2ck10 = 1.8 time = 220
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=220.1n

* CHECK dout0_3 Vdout0_3ck10 = 1.8 time = 220
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=220.1n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 220
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=220.1n

* CHECK dout0_5 Vdout0_5ck10 = 1.8 time = 220
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=220.1n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 220
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=220.1n

* CHECK dout0_7 Vdout0_7ck10 = 1.8 time = 220
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=220.1n

* CHECK dout0_8 Vdout0_8ck10 = 0 time = 220
.meas tran vdout0_8ck10 FIND v(dout0_8) AT=220.1n

* CHECK dout0_9 Vdout0_9ck10 = 1.8 time = 220
.meas tran vdout0_9ck10 FIND v(dout0_9) AT=220.1n

* CHECK dout0_10 Vdout0_10ck10 = 1.8 time = 220
.meas tran vdout0_10ck10 FIND v(dout0_10) AT=220.1n

* CHECK dout0_11 Vdout0_11ck10 = 1.8 time = 220
.meas tran vdout0_11ck10 FIND v(dout0_11) AT=220.1n

* CHECK dout0_12 Vdout0_12ck10 = 0 time = 220
.meas tran vdout0_12ck10 FIND v(dout0_12) AT=220.1n

* CHECK dout0_13 Vdout0_13ck10 = 0 time = 220
.meas tran vdout0_13ck10 FIND v(dout0_13) AT=220.1n

* CHECK dout0_14 Vdout0_14ck10 = 0 time = 220
.meas tran vdout0_14ck10 FIND v(dout0_14) AT=220.1n

* CHECK dout0_15 Vdout0_15ck10 = 0 time = 220
.meas tran vdout0_15ck10 FIND v(dout0_15) AT=220.1n

* CHECK dout0_16 Vdout0_16ck10 = 0 time = 220
.meas tran vdout0_16ck10 FIND v(dout0_16) AT=220.1n

* CHECK dout0_17 Vdout0_17ck10 = 0 time = 220
.meas tran vdout0_17ck10 FIND v(dout0_17) AT=220.1n

* CHECK dout0_18 Vdout0_18ck10 = 0 time = 220
.meas tran vdout0_18ck10 FIND v(dout0_18) AT=220.1n

* CHECK dout0_19 Vdout0_19ck10 = 0 time = 220
.meas tran vdout0_19ck10 FIND v(dout0_19) AT=220.1n

* CHECK dout0_20 Vdout0_20ck10 = 1.8 time = 220
.meas tran vdout0_20ck10 FIND v(dout0_20) AT=220.1n

* CHECK dout0_21 Vdout0_21ck10 = 1.8 time = 220
.meas tran vdout0_21ck10 FIND v(dout0_21) AT=220.1n

* CHECK dout0_22 Vdout0_22ck10 = 0 time = 220
.meas tran vdout0_22ck10 FIND v(dout0_22) AT=220.1n

* CHECK dout0_23 Vdout0_23ck10 = 1.8 time = 220
.meas tran vdout0_23ck10 FIND v(dout0_23) AT=220.1n

* CHECK dout0_24 Vdout0_24ck10 = 1.8 time = 220
.meas tran vdout0_24ck10 FIND v(dout0_24) AT=220.1n

* CHECK dout0_25 Vdout0_25ck10 = 0 time = 220
.meas tran vdout0_25ck10 FIND v(dout0_25) AT=220.1n

* CHECK dout0_26 Vdout0_26ck10 = 0 time = 220
.meas tran vdout0_26ck10 FIND v(dout0_26) AT=220.1n

* CHECK dout0_27 Vdout0_27ck10 = 0 time = 220
.meas tran vdout0_27ck10 FIND v(dout0_27) AT=220.1n

* CHECK dout0_28 Vdout0_28ck10 = 1.8 time = 220
.meas tran vdout0_28ck10 FIND v(dout0_28) AT=220.1n

* CHECK dout0_29 Vdout0_29ck10 = 0 time = 220
.meas tran vdout0_29ck10 FIND v(dout0_29) AT=220.1n

* CHECK dout0_30 Vdout0_30ck10 = 0 time = 220
.meas tran vdout0_30ck10 FIND v(dout0_30) AT=220.1n

* CHECK dout0_31 Vdout0_31ck10 = 1.8 time = 220
.meas tran vdout0_31ck10 FIND v(dout0_31) AT=220.1n

* CHECK dout0_0 Vdout0_0ck12 = 1.8 time = 260
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=260.1n

* CHECK dout0_1 Vdout0_1ck12 = 1.8 time = 260
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=260.1n

* CHECK dout0_2 Vdout0_2ck12 = 0 time = 260
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=260.1n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 260
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=260.1n

* CHECK dout0_4 Vdout0_4ck12 = 0 time = 260
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=260.1n

* CHECK dout0_5 Vdout0_5ck12 = 0 time = 260
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=260.1n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 260
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=260.1n

* CHECK dout0_7 Vdout0_7ck12 = 0 time = 260
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=260.1n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 260
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=260.1n

* CHECK dout0_9 Vdout0_9ck12 = 1.8 time = 260
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=260.1n

* CHECK dout0_10 Vdout0_10ck12 = 1.8 time = 260
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=260.1n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 260
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=260.1n

* CHECK dout0_12 Vdout0_12ck12 = 1.8 time = 260
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=260.1n

* CHECK dout0_13 Vdout0_13ck12 = 1.8 time = 260
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=260.1n

* CHECK dout0_14 Vdout0_14ck12 = 1.8 time = 260
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=260.1n

* CHECK dout0_15 Vdout0_15ck12 = 0 time = 260
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=260.1n

* CHECK dout0_16 Vdout0_16ck12 = 0 time = 260
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=260.1n

* CHECK dout0_17 Vdout0_17ck12 = 1.8 time = 260
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=260.1n

* CHECK dout0_18 Vdout0_18ck12 = 0 time = 260
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=260.1n

* CHECK dout0_19 Vdout0_19ck12 = 1.8 time = 260
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=260.1n

* CHECK dout0_20 Vdout0_20ck12 = 0 time = 260
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=260.1n

* CHECK dout0_21 Vdout0_21ck12 = 1.8 time = 260
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=260.1n

* CHECK dout0_22 Vdout0_22ck12 = 1.8 time = 260
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=260.1n

* CHECK dout0_23 Vdout0_23ck12 = 1.8 time = 260
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=260.1n

* CHECK dout0_24 Vdout0_24ck12 = 0 time = 260
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=260.1n

* CHECK dout0_25 Vdout0_25ck12 = 0 time = 260
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=260.1n

* CHECK dout0_26 Vdout0_26ck12 = 1.8 time = 260
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=260.1n

* CHECK dout0_27 Vdout0_27ck12 = 1.8 time = 260
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=260.1n

* CHECK dout0_28 Vdout0_28ck12 = 0 time = 260
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=260.1n

* CHECK dout0_29 Vdout0_29ck12 = 1.8 time = 260
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=260.1n

* CHECK dout0_30 Vdout0_30ck12 = 1.8 time = 260
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=260.1n

* CHECK dout0_31 Vdout0_31ck12 = 0 time = 260
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=260.1n

* CHECK dout0_0 Vdout0_0ck13 = 0 time = 280
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=280.1n

* CHECK dout0_1 Vdout0_1ck13 = 1.8 time = 280
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=280.1n

* CHECK dout0_2 Vdout0_2ck13 = 1.8 time = 280
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=280.1n

* CHECK dout0_3 Vdout0_3ck13 = 1.8 time = 280
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=280.1n

* CHECK dout0_4 Vdout0_4ck13 = 0 time = 280
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=280.1n

* CHECK dout0_5 Vdout0_5ck13 = 1.8 time = 280
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=280.1n

* CHECK dout0_6 Vdout0_6ck13 = 0 time = 280
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=280.1n

* CHECK dout0_7 Vdout0_7ck13 = 1.8 time = 280
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=280.1n

* CHECK dout0_8 Vdout0_8ck13 = 0 time = 280
.meas tran vdout0_8ck13 FIND v(dout0_8) AT=280.1n

* CHECK dout0_9 Vdout0_9ck13 = 1.8 time = 280
.meas tran vdout0_9ck13 FIND v(dout0_9) AT=280.1n

* CHECK dout0_10 Vdout0_10ck13 = 1.8 time = 280
.meas tran vdout0_10ck13 FIND v(dout0_10) AT=280.1n

* CHECK dout0_11 Vdout0_11ck13 = 1.8 time = 280
.meas tran vdout0_11ck13 FIND v(dout0_11) AT=280.1n

* CHECK dout0_12 Vdout0_12ck13 = 0 time = 280
.meas tran vdout0_12ck13 FIND v(dout0_12) AT=280.1n

* CHECK dout0_13 Vdout0_13ck13 = 0 time = 280
.meas tran vdout0_13ck13 FIND v(dout0_13) AT=280.1n

* CHECK dout0_14 Vdout0_14ck13 = 0 time = 280
.meas tran vdout0_14ck13 FIND v(dout0_14) AT=280.1n

* CHECK dout0_15 Vdout0_15ck13 = 0 time = 280
.meas tran vdout0_15ck13 FIND v(dout0_15) AT=280.1n

* CHECK dout0_16 Vdout0_16ck13 = 0 time = 280
.meas tran vdout0_16ck13 FIND v(dout0_16) AT=280.1n

* CHECK dout0_17 Vdout0_17ck13 = 0 time = 280
.meas tran vdout0_17ck13 FIND v(dout0_17) AT=280.1n

* CHECK dout0_18 Vdout0_18ck13 = 0 time = 280
.meas tran vdout0_18ck13 FIND v(dout0_18) AT=280.1n

* CHECK dout0_19 Vdout0_19ck13 = 0 time = 280
.meas tran vdout0_19ck13 FIND v(dout0_19) AT=280.1n

* CHECK dout0_20 Vdout0_20ck13 = 1.8 time = 280
.meas tran vdout0_20ck13 FIND v(dout0_20) AT=280.1n

* CHECK dout0_21 Vdout0_21ck13 = 1.8 time = 280
.meas tran vdout0_21ck13 FIND v(dout0_21) AT=280.1n

* CHECK dout0_22 Vdout0_22ck13 = 0 time = 280
.meas tran vdout0_22ck13 FIND v(dout0_22) AT=280.1n

* CHECK dout0_23 Vdout0_23ck13 = 1.8 time = 280
.meas tran vdout0_23ck13 FIND v(dout0_23) AT=280.1n

* CHECK dout0_24 Vdout0_24ck13 = 1.8 time = 280
.meas tran vdout0_24ck13 FIND v(dout0_24) AT=280.1n

* CHECK dout0_25 Vdout0_25ck13 = 0 time = 280
.meas tran vdout0_25ck13 FIND v(dout0_25) AT=280.1n

* CHECK dout0_26 Vdout0_26ck13 = 0 time = 280
.meas tran vdout0_26ck13 FIND v(dout0_26) AT=280.1n

* CHECK dout0_27 Vdout0_27ck13 = 0 time = 280
.meas tran vdout0_27ck13 FIND v(dout0_27) AT=280.1n

* CHECK dout0_28 Vdout0_28ck13 = 1.8 time = 280
.meas tran vdout0_28ck13 FIND v(dout0_28) AT=280.1n

* CHECK dout0_29 Vdout0_29ck13 = 0 time = 280
.meas tran vdout0_29ck13 FIND v(dout0_29) AT=280.1n

* CHECK dout0_30 Vdout0_30ck13 = 0 time = 280
.meas tran vdout0_30ck13 FIND v(dout0_30) AT=280.1n

* CHECK dout0_31 Vdout0_31ck13 = 1.8 time = 280
.meas tran vdout0_31ck13 FIND v(dout0_31) AT=280.1n

* CHECK dout0_0 Vdout0_0ck16 = 0 time = 340
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=340.1n

* CHECK dout0_1 Vdout0_1ck16 = 0 time = 340
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=340.1n

* CHECK dout0_2 Vdout0_2ck16 = 0 time = 340
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=340.1n

* CHECK dout0_3 Vdout0_3ck16 = 0 time = 340
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=340.1n

* CHECK dout0_4 Vdout0_4ck16 = 1.8 time = 340
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=340.1n

* CHECK dout0_5 Vdout0_5ck16 = 0 time = 340
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=340.1n

* CHECK dout0_6 Vdout0_6ck16 = 0 time = 340
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=340.1n

* CHECK dout0_7 Vdout0_7ck16 = 0 time = 340
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=340.1n

* CHECK dout0_8 Vdout0_8ck16 = 1.8 time = 340
.meas tran vdout0_8ck16 FIND v(dout0_8) AT=340.1n

* CHECK dout0_9 Vdout0_9ck16 = 0 time = 340
.meas tran vdout0_9ck16 FIND v(dout0_9) AT=340.1n

* CHECK dout0_10 Vdout0_10ck16 = 0 time = 340
.meas tran vdout0_10ck16 FIND v(dout0_10) AT=340.1n

* CHECK dout0_11 Vdout0_11ck16 = 1.8 time = 340
.meas tran vdout0_11ck16 FIND v(dout0_11) AT=340.1n

* CHECK dout0_12 Vdout0_12ck16 = 0 time = 340
.meas tran vdout0_12ck16 FIND v(dout0_12) AT=340.1n

* CHECK dout0_13 Vdout0_13ck16 = 0 time = 340
.meas tran vdout0_13ck16 FIND v(dout0_13) AT=340.1n

* CHECK dout0_14 Vdout0_14ck16 = 1.8 time = 340
.meas tran vdout0_14ck16 FIND v(dout0_14) AT=340.1n

* CHECK dout0_15 Vdout0_15ck16 = 1.8 time = 340
.meas tran vdout0_15ck16 FIND v(dout0_15) AT=340.1n

* CHECK dout0_16 Vdout0_16ck16 = 1.8 time = 340
.meas tran vdout0_16ck16 FIND v(dout0_16) AT=340.1n

* CHECK dout0_17 Vdout0_17ck16 = 1.8 time = 340
.meas tran vdout0_17ck16 FIND v(dout0_17) AT=340.1n

* CHECK dout0_18 Vdout0_18ck16 = 1.8 time = 340
.meas tran vdout0_18ck16 FIND v(dout0_18) AT=340.1n

* CHECK dout0_19 Vdout0_19ck16 = 1.8 time = 340
.meas tran vdout0_19ck16 FIND v(dout0_19) AT=340.1n

* CHECK dout0_20 Vdout0_20ck16 = 0 time = 340
.meas tran vdout0_20ck16 FIND v(dout0_20) AT=340.1n

* CHECK dout0_21 Vdout0_21ck16 = 1.8 time = 340
.meas tran vdout0_21ck16 FIND v(dout0_21) AT=340.1n

* CHECK dout0_22 Vdout0_22ck16 = 1.8 time = 340
.meas tran vdout0_22ck16 FIND v(dout0_22) AT=340.1n

* CHECK dout0_23 Vdout0_23ck16 = 1.8 time = 340
.meas tran vdout0_23ck16 FIND v(dout0_23) AT=340.1n

* CHECK dout0_24 Vdout0_24ck16 = 1.8 time = 340
.meas tran vdout0_24ck16 FIND v(dout0_24) AT=340.1n

* CHECK dout0_25 Vdout0_25ck16 = 0 time = 340
.meas tran vdout0_25ck16 FIND v(dout0_25) AT=340.1n

* CHECK dout0_26 Vdout0_26ck16 = 1.8 time = 340
.meas tran vdout0_26ck16 FIND v(dout0_26) AT=340.1n

* CHECK dout0_27 Vdout0_27ck16 = 1.8 time = 340
.meas tran vdout0_27ck16 FIND v(dout0_27) AT=340.1n

* CHECK dout0_28 Vdout0_28ck16 = 0 time = 340
.meas tran vdout0_28ck16 FIND v(dout0_28) AT=340.1n

* CHECK dout0_29 Vdout0_29ck16 = 0 time = 340
.meas tran vdout0_29ck16 FIND v(dout0_29) AT=340.1n

* CHECK dout0_30 Vdout0_30ck16 = 0 time = 340
.meas tran vdout0_30ck16 FIND v(dout0_30) AT=340.1n

* CHECK dout0_31 Vdout0_31ck16 = 1.8 time = 340
.meas tran vdout0_31ck16 FIND v(dout0_31) AT=340.1n

* CHECK dout0_0 Vdout0_0ck17 = 1.8 time = 360
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=360.1n

* CHECK dout0_1 Vdout0_1ck17 = 0 time = 360
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=360.1n

* CHECK dout0_2 Vdout0_2ck17 = 1.8 time = 360
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=360.1n

* CHECK dout0_3 Vdout0_3ck17 = 0 time = 360
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=360.1n

* CHECK dout0_4 Vdout0_4ck17 = 0 time = 360
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=360.1n

* CHECK dout0_5 Vdout0_5ck17 = 0 time = 360
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=360.1n

* CHECK dout0_6 Vdout0_6ck17 = 0 time = 360
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=360.1n

* CHECK dout0_7 Vdout0_7ck17 = 1.8 time = 360
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=360.1n

* CHECK dout0_8 Vdout0_8ck17 = 0 time = 360
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=360.1n

* CHECK dout0_9 Vdout0_9ck17 = 1.8 time = 360
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=360.1n

* CHECK dout0_10 Vdout0_10ck17 = 0 time = 360
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=360.1n

* CHECK dout0_11 Vdout0_11ck17 = 1.8 time = 360
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=360.1n

* CHECK dout0_12 Vdout0_12ck17 = 1.8 time = 360
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=360.1n

* CHECK dout0_13 Vdout0_13ck17 = 1.8 time = 360
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=360.1n

* CHECK dout0_14 Vdout0_14ck17 = 0 time = 360
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=360.1n

* CHECK dout0_15 Vdout0_15ck17 = 0 time = 360
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=360.1n

* CHECK dout0_16 Vdout0_16ck17 = 1.8 time = 360
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=360.1n

* CHECK dout0_17 Vdout0_17ck17 = 1.8 time = 360
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=360.1n

* CHECK dout0_18 Vdout0_18ck17 = 1.8 time = 360
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=360.1n

* CHECK dout0_19 Vdout0_19ck17 = 0 time = 360
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=360.1n

* CHECK dout0_20 Vdout0_20ck17 = 0 time = 360
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=360.1n

* CHECK dout0_21 Vdout0_21ck17 = 0 time = 360
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=360.1n

* CHECK dout0_22 Vdout0_22ck17 = 1.8 time = 360
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=360.1n

* CHECK dout0_23 Vdout0_23ck17 = 1.8 time = 360
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=360.1n

* CHECK dout0_24 Vdout0_24ck17 = 1.8 time = 360
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=360.1n

* CHECK dout0_25 Vdout0_25ck17 = 1.8 time = 360
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=360.1n

* CHECK dout0_26 Vdout0_26ck17 = 0 time = 360
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=360.1n

* CHECK dout0_27 Vdout0_27ck17 = 1.8 time = 360
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=360.1n

* CHECK dout0_28 Vdout0_28ck17 = 1.8 time = 360
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=360.1n

* CHECK dout0_29 Vdout0_29ck17 = 0 time = 360
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=360.1n

* CHECK dout0_30 Vdout0_30ck17 = 1.8 time = 360
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=360.1n

* CHECK dout0_31 Vdout0_31ck17 = 1.8 time = 360
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=360.1n

* CHECK dout0_0 Vdout0_0ck18 = 1.8 time = 380
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=380.1n

* CHECK dout0_1 Vdout0_1ck18 = 0 time = 380
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=380.1n

* CHECK dout0_2 Vdout0_2ck18 = 1.8 time = 380
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=380.1n

* CHECK dout0_3 Vdout0_3ck18 = 0 time = 380
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=380.1n

* CHECK dout0_4 Vdout0_4ck18 = 0 time = 380
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=380.1n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 380
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=380.1n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 380
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=380.1n

* CHECK dout0_7 Vdout0_7ck18 = 1.8 time = 380
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=380.1n

* CHECK dout0_8 Vdout0_8ck18 = 0 time = 380
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=380.1n

* CHECK dout0_9 Vdout0_9ck18 = 1.8 time = 380
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=380.1n

* CHECK dout0_10 Vdout0_10ck18 = 0 time = 380
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=380.1n

* CHECK dout0_11 Vdout0_11ck18 = 1.8 time = 380
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=380.1n

* CHECK dout0_12 Vdout0_12ck18 = 1.8 time = 380
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=380.1n

* CHECK dout0_13 Vdout0_13ck18 = 1.8 time = 380
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=380.1n

* CHECK dout0_14 Vdout0_14ck18 = 0 time = 380
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=380.1n

* CHECK dout0_15 Vdout0_15ck18 = 0 time = 380
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=380.1n

* CHECK dout0_16 Vdout0_16ck18 = 1.8 time = 380
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=380.1n

* CHECK dout0_17 Vdout0_17ck18 = 1.8 time = 380
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=380.1n

* CHECK dout0_18 Vdout0_18ck18 = 1.8 time = 380
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=380.1n

* CHECK dout0_19 Vdout0_19ck18 = 0 time = 380
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=380.1n

* CHECK dout0_20 Vdout0_20ck18 = 0 time = 380
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=380.1n

* CHECK dout0_21 Vdout0_21ck18 = 0 time = 380
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=380.1n

* CHECK dout0_22 Vdout0_22ck18 = 1.8 time = 380
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=380.1n

* CHECK dout0_23 Vdout0_23ck18 = 1.8 time = 380
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=380.1n

* CHECK dout0_24 Vdout0_24ck18 = 1.8 time = 380
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=380.1n

* CHECK dout0_25 Vdout0_25ck18 = 1.8 time = 380
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=380.1n

* CHECK dout0_26 Vdout0_26ck18 = 0 time = 380
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=380.1n

* CHECK dout0_27 Vdout0_27ck18 = 1.8 time = 380
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=380.1n

* CHECK dout0_28 Vdout0_28ck18 = 1.8 time = 380
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=380.1n

* CHECK dout0_29 Vdout0_29ck18 = 0 time = 380
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=380.1n

* CHECK dout0_30 Vdout0_30ck18 = 1.8 time = 380
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=380.1n

* CHECK dout0_31 Vdout0_31ck18 = 1.8 time = 380
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=380.1n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 400
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=400.1n

* CHECK dout0_1 Vdout0_1ck19 = 1.8 time = 400
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=400.1n

* CHECK dout0_2 Vdout0_2ck19 = 1.8 time = 400
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=400.1n

* CHECK dout0_3 Vdout0_3ck19 = 1.8 time = 400
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=400.1n

* CHECK dout0_4 Vdout0_4ck19 = 0 time = 400
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=400.1n

* CHECK dout0_5 Vdout0_5ck19 = 1.8 time = 400
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=400.1n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 400
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=400.1n

* CHECK dout0_7 Vdout0_7ck19 = 1.8 time = 400
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=400.1n

* CHECK dout0_8 Vdout0_8ck19 = 0 time = 400
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=400.1n

* CHECK dout0_9 Vdout0_9ck19 = 1.8 time = 400
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=400.1n

* CHECK dout0_10 Vdout0_10ck19 = 1.8 time = 400
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=400.1n

* CHECK dout0_11 Vdout0_11ck19 = 1.8 time = 400
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=400.1n

* CHECK dout0_12 Vdout0_12ck19 = 0 time = 400
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=400.1n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 400
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=400.1n

* CHECK dout0_14 Vdout0_14ck19 = 0 time = 400
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=400.1n

* CHECK dout0_15 Vdout0_15ck19 = 0 time = 400
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=400.1n

* CHECK dout0_16 Vdout0_16ck19 = 0 time = 400
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=400.1n

* CHECK dout0_17 Vdout0_17ck19 = 0 time = 400
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=400.1n

* CHECK dout0_18 Vdout0_18ck19 = 0 time = 400
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=400.1n

* CHECK dout0_19 Vdout0_19ck19 = 0 time = 400
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=400.1n

* CHECK dout0_20 Vdout0_20ck19 = 1.8 time = 400
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=400.1n

* CHECK dout0_21 Vdout0_21ck19 = 1.8 time = 400
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=400.1n

* CHECK dout0_22 Vdout0_22ck19 = 0 time = 400
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=400.1n

* CHECK dout0_23 Vdout0_23ck19 = 1.8 time = 400
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=400.1n

* CHECK dout0_24 Vdout0_24ck19 = 1.8 time = 400
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=400.1n

* CHECK dout0_25 Vdout0_25ck19 = 0 time = 400
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=400.1n

* CHECK dout0_26 Vdout0_26ck19 = 0 time = 400
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=400.1n

* CHECK dout0_27 Vdout0_27ck19 = 0 time = 400
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=400.1n

* CHECK dout0_28 Vdout0_28ck19 = 1.8 time = 400
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=400.1n

* CHECK dout0_29 Vdout0_29ck19 = 0 time = 400
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=400.1n

* CHECK dout0_30 Vdout0_30ck19 = 0 time = 400
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=400.1n

* CHECK dout0_31 Vdout0_31ck19 = 1.8 time = 400
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=400.1n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 500
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=500.1n

* CHECK dout0_1 Vdout0_1ck24 = 0 time = 500
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=500.1n

* CHECK dout0_2 Vdout0_2ck24 = 0 time = 500
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=500.1n

* CHECK dout0_3 Vdout0_3ck24 = 0 time = 500
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=500.1n

* CHECK dout0_4 Vdout0_4ck24 = 1.8 time = 500
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=500.1n

* CHECK dout0_5 Vdout0_5ck24 = 0 time = 500
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=500.1n

* CHECK dout0_6 Vdout0_6ck24 = 0 time = 500
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=500.1n

* CHECK dout0_7 Vdout0_7ck24 = 0 time = 500
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=500.1n

* CHECK dout0_8 Vdout0_8ck24 = 1.8 time = 500
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=500.1n

* CHECK dout0_9 Vdout0_9ck24 = 0 time = 500
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=500.1n

* CHECK dout0_10 Vdout0_10ck24 = 0 time = 500
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=500.1n

* CHECK dout0_11 Vdout0_11ck24 = 1.8 time = 500
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=500.1n

* CHECK dout0_12 Vdout0_12ck24 = 0 time = 500
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=500.1n

* CHECK dout0_13 Vdout0_13ck24 = 0 time = 500
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=500.1n

* CHECK dout0_14 Vdout0_14ck24 = 1.8 time = 500
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=500.1n

* CHECK dout0_15 Vdout0_15ck24 = 1.8 time = 500
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=500.1n

* CHECK dout0_16 Vdout0_16ck24 = 1.8 time = 500
.meas tran vdout0_16ck24 FIND v(dout0_16) AT=500.1n

* CHECK dout0_17 Vdout0_17ck24 = 1.8 time = 500
.meas tran vdout0_17ck24 FIND v(dout0_17) AT=500.1n

* CHECK dout0_18 Vdout0_18ck24 = 1.8 time = 500
.meas tran vdout0_18ck24 FIND v(dout0_18) AT=500.1n

* CHECK dout0_19 Vdout0_19ck24 = 1.8 time = 500
.meas tran vdout0_19ck24 FIND v(dout0_19) AT=500.1n

* CHECK dout0_20 Vdout0_20ck24 = 0 time = 500
.meas tran vdout0_20ck24 FIND v(dout0_20) AT=500.1n

* CHECK dout0_21 Vdout0_21ck24 = 1.8 time = 500
.meas tran vdout0_21ck24 FIND v(dout0_21) AT=500.1n

* CHECK dout0_22 Vdout0_22ck24 = 1.8 time = 500
.meas tran vdout0_22ck24 FIND v(dout0_22) AT=500.1n

* CHECK dout0_23 Vdout0_23ck24 = 1.8 time = 500
.meas tran vdout0_23ck24 FIND v(dout0_23) AT=500.1n

* CHECK dout0_24 Vdout0_24ck24 = 1.8 time = 500
.meas tran vdout0_24ck24 FIND v(dout0_24) AT=500.1n

* CHECK dout0_25 Vdout0_25ck24 = 0 time = 500
.meas tran vdout0_25ck24 FIND v(dout0_25) AT=500.1n

* CHECK dout0_26 Vdout0_26ck24 = 1.8 time = 500
.meas tran vdout0_26ck24 FIND v(dout0_26) AT=500.1n

* CHECK dout0_27 Vdout0_27ck24 = 1.8 time = 500
.meas tran vdout0_27ck24 FIND v(dout0_27) AT=500.1n

* CHECK dout0_28 Vdout0_28ck24 = 0 time = 500
.meas tran vdout0_28ck24 FIND v(dout0_28) AT=500.1n

* CHECK dout0_29 Vdout0_29ck24 = 0 time = 500
.meas tran vdout0_29ck24 FIND v(dout0_29) AT=500.1n

* CHECK dout0_30 Vdout0_30ck24 = 0 time = 500
.meas tran vdout0_30ck24 FIND v(dout0_30) AT=500.1n

* CHECK dout0_31 Vdout0_31ck24 = 1.8 time = 500
.meas tran vdout0_31ck24 FIND v(dout0_31) AT=500.1n

* CHECK dout0_0 Vdout0_0ck25 = 0 time = 520
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=520.1n

* CHECK dout0_1 Vdout0_1ck25 = 1.8 time = 520
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=520.1n

* CHECK dout0_2 Vdout0_2ck25 = 1.8 time = 520
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=520.1n

* CHECK dout0_3 Vdout0_3ck25 = 1.8 time = 520
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=520.1n

* CHECK dout0_4 Vdout0_4ck25 = 0 time = 520
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=520.1n

* CHECK dout0_5 Vdout0_5ck25 = 1.8 time = 520
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=520.1n

* CHECK dout0_6 Vdout0_6ck25 = 0 time = 520
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=520.1n

* CHECK dout0_7 Vdout0_7ck25 = 1.8 time = 520
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=520.1n

* CHECK dout0_8 Vdout0_8ck25 = 0 time = 520
.meas tran vdout0_8ck25 FIND v(dout0_8) AT=520.1n

* CHECK dout0_9 Vdout0_9ck25 = 1.8 time = 520
.meas tran vdout0_9ck25 FIND v(dout0_9) AT=520.1n

* CHECK dout0_10 Vdout0_10ck25 = 1.8 time = 520
.meas tran vdout0_10ck25 FIND v(dout0_10) AT=520.1n

* CHECK dout0_11 Vdout0_11ck25 = 1.8 time = 520
.meas tran vdout0_11ck25 FIND v(dout0_11) AT=520.1n

* CHECK dout0_12 Vdout0_12ck25 = 0 time = 520
.meas tran vdout0_12ck25 FIND v(dout0_12) AT=520.1n

* CHECK dout0_13 Vdout0_13ck25 = 0 time = 520
.meas tran vdout0_13ck25 FIND v(dout0_13) AT=520.1n

* CHECK dout0_14 Vdout0_14ck25 = 0 time = 520
.meas tran vdout0_14ck25 FIND v(dout0_14) AT=520.1n

* CHECK dout0_15 Vdout0_15ck25 = 0 time = 520
.meas tran vdout0_15ck25 FIND v(dout0_15) AT=520.1n

* CHECK dout0_16 Vdout0_16ck25 = 0 time = 520
.meas tran vdout0_16ck25 FIND v(dout0_16) AT=520.1n

* CHECK dout0_17 Vdout0_17ck25 = 0 time = 520
.meas tran vdout0_17ck25 FIND v(dout0_17) AT=520.1n

* CHECK dout0_18 Vdout0_18ck25 = 0 time = 520
.meas tran vdout0_18ck25 FIND v(dout0_18) AT=520.1n

* CHECK dout0_19 Vdout0_19ck25 = 0 time = 520
.meas tran vdout0_19ck25 FIND v(dout0_19) AT=520.1n

* CHECK dout0_20 Vdout0_20ck25 = 1.8 time = 520
.meas tran vdout0_20ck25 FIND v(dout0_20) AT=520.1n

* CHECK dout0_21 Vdout0_21ck25 = 1.8 time = 520
.meas tran vdout0_21ck25 FIND v(dout0_21) AT=520.1n

* CHECK dout0_22 Vdout0_22ck25 = 0 time = 520
.meas tran vdout0_22ck25 FIND v(dout0_22) AT=520.1n

* CHECK dout0_23 Vdout0_23ck25 = 1.8 time = 520
.meas tran vdout0_23ck25 FIND v(dout0_23) AT=520.1n

* CHECK dout0_24 Vdout0_24ck25 = 1.8 time = 520
.meas tran vdout0_24ck25 FIND v(dout0_24) AT=520.1n

* CHECK dout0_25 Vdout0_25ck25 = 0 time = 520
.meas tran vdout0_25ck25 FIND v(dout0_25) AT=520.1n

* CHECK dout0_26 Vdout0_26ck25 = 0 time = 520
.meas tran vdout0_26ck25 FIND v(dout0_26) AT=520.1n

* CHECK dout0_27 Vdout0_27ck25 = 0 time = 520
.meas tran vdout0_27ck25 FIND v(dout0_27) AT=520.1n

* CHECK dout0_28 Vdout0_28ck25 = 1.8 time = 520
.meas tran vdout0_28ck25 FIND v(dout0_28) AT=520.1n

* CHECK dout0_29 Vdout0_29ck25 = 0 time = 520
.meas tran vdout0_29ck25 FIND v(dout0_29) AT=520.1n

* CHECK dout0_30 Vdout0_30ck25 = 0 time = 520
.meas tran vdout0_30ck25 FIND v(dout0_30) AT=520.1n

* CHECK dout0_31 Vdout0_31ck25 = 1.8 time = 520
.meas tran vdout0_31ck25 FIND v(dout0_31) AT=520.1n

* CHECK dout0_0 Vdout0_0ck26 = 1.8 time = 540
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=540.1n

* CHECK dout0_1 Vdout0_1ck26 = 1.8 time = 540
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=540.1n

* CHECK dout0_2 Vdout0_2ck26 = 1.8 time = 540
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=540.1n

* CHECK dout0_3 Vdout0_3ck26 = 0 time = 540
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=540.1n

* CHECK dout0_4 Vdout0_4ck26 = 0 time = 540
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=540.1n

* CHECK dout0_5 Vdout0_5ck26 = 1.8 time = 540
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=540.1n

* CHECK dout0_6 Vdout0_6ck26 = 0 time = 540
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=540.1n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 540
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=540.1n

* CHECK dout0_8 Vdout0_8ck26 = 0 time = 540
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=540.1n

* CHECK dout0_9 Vdout0_9ck26 = 0 time = 540
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=540.1n

* CHECK dout0_10 Vdout0_10ck26 = 0 time = 540
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=540.1n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 540
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=540.1n

* CHECK dout0_12 Vdout0_12ck26 = 1.8 time = 540
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=540.1n

* CHECK dout0_13 Vdout0_13ck26 = 0 time = 540
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=540.1n

* CHECK dout0_14 Vdout0_14ck26 = 1.8 time = 540
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=540.1n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 540
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=540.1n

* CHECK dout0_16 Vdout0_16ck26 = 1.8 time = 540
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=540.1n

* CHECK dout0_17 Vdout0_17ck26 = 0 time = 540
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=540.1n

* CHECK dout0_18 Vdout0_18ck26 = 1.8 time = 540
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=540.1n

* CHECK dout0_19 Vdout0_19ck26 = 1.8 time = 540
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=540.1n

* CHECK dout0_20 Vdout0_20ck26 = 1.8 time = 540
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=540.1n

* CHECK dout0_21 Vdout0_21ck26 = 1.8 time = 540
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=540.1n

* CHECK dout0_22 Vdout0_22ck26 = 0 time = 540
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=540.1n

* CHECK dout0_23 Vdout0_23ck26 = 0 time = 540
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=540.1n

* CHECK dout0_24 Vdout0_24ck26 = 1.8 time = 540
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=540.1n

* CHECK dout0_25 Vdout0_25ck26 = 0 time = 540
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=540.1n

* CHECK dout0_26 Vdout0_26ck26 = 0 time = 540
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=540.1n

* CHECK dout0_27 Vdout0_27ck26 = 1.8 time = 540
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=540.1n

* CHECK dout0_28 Vdout0_28ck26 = 1.8 time = 540
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=540.1n

* CHECK dout0_29 Vdout0_29ck26 = 0 time = 540
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=540.1n

* CHECK dout0_30 Vdout0_30ck26 = 1.8 time = 540
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=540.1n

* CHECK dout0_31 Vdout0_31ck26 = 1.8 time = 540
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=540.1n

* CHECK dout0_0 Vdout0_0ck27 = 1.8 time = 560
.meas tran vdout0_0ck27 FIND v(dout0_0) AT=560.1n

* CHECK dout0_1 Vdout0_1ck27 = 1.8 time = 560
.meas tran vdout0_1ck27 FIND v(dout0_1) AT=560.1n

* CHECK dout0_2 Vdout0_2ck27 = 1.8 time = 560
.meas tran vdout0_2ck27 FIND v(dout0_2) AT=560.1n

* CHECK dout0_3 Vdout0_3ck27 = 1.8 time = 560
.meas tran vdout0_3ck27 FIND v(dout0_3) AT=560.1n

* CHECK dout0_4 Vdout0_4ck27 = 0 time = 560
.meas tran vdout0_4ck27 FIND v(dout0_4) AT=560.1n

* CHECK dout0_5 Vdout0_5ck27 = 0 time = 560
.meas tran vdout0_5ck27 FIND v(dout0_5) AT=560.1n

* CHECK dout0_6 Vdout0_6ck27 = 1.8 time = 560
.meas tran vdout0_6ck27 FIND v(dout0_6) AT=560.1n

* CHECK dout0_7 Vdout0_7ck27 = 0 time = 560
.meas tran vdout0_7ck27 FIND v(dout0_7) AT=560.1n

* CHECK dout0_8 Vdout0_8ck27 = 0 time = 560
.meas tran vdout0_8ck27 FIND v(dout0_8) AT=560.1n

* CHECK dout0_9 Vdout0_9ck27 = 0 time = 560
.meas tran vdout0_9ck27 FIND v(dout0_9) AT=560.1n

* CHECK dout0_10 Vdout0_10ck27 = 0 time = 560
.meas tran vdout0_10ck27 FIND v(dout0_10) AT=560.1n

* CHECK dout0_11 Vdout0_11ck27 = 1.8 time = 560
.meas tran vdout0_11ck27 FIND v(dout0_11) AT=560.1n

* CHECK dout0_12 Vdout0_12ck27 = 1.8 time = 560
.meas tran vdout0_12ck27 FIND v(dout0_12) AT=560.1n

* CHECK dout0_13 Vdout0_13ck27 = 0 time = 560
.meas tran vdout0_13ck27 FIND v(dout0_13) AT=560.1n

* CHECK dout0_14 Vdout0_14ck27 = 1.8 time = 560
.meas tran vdout0_14ck27 FIND v(dout0_14) AT=560.1n

* CHECK dout0_15 Vdout0_15ck27 = 1.8 time = 560
.meas tran vdout0_15ck27 FIND v(dout0_15) AT=560.1n

* CHECK dout0_16 Vdout0_16ck27 = 1.8 time = 560
.meas tran vdout0_16ck27 FIND v(dout0_16) AT=560.1n

* CHECK dout0_17 Vdout0_17ck27 = 1.8 time = 560
.meas tran vdout0_17ck27 FIND v(dout0_17) AT=560.1n

* CHECK dout0_18 Vdout0_18ck27 = 1.8 time = 560
.meas tran vdout0_18ck27 FIND v(dout0_18) AT=560.1n

* CHECK dout0_19 Vdout0_19ck27 = 0 time = 560
.meas tran vdout0_19ck27 FIND v(dout0_19) AT=560.1n

* CHECK dout0_20 Vdout0_20ck27 = 1.8 time = 560
.meas tran vdout0_20ck27 FIND v(dout0_20) AT=560.1n

* CHECK dout0_21 Vdout0_21ck27 = 1.8 time = 560
.meas tran vdout0_21ck27 FIND v(dout0_21) AT=560.1n

* CHECK dout0_22 Vdout0_22ck27 = 1.8 time = 560
.meas tran vdout0_22ck27 FIND v(dout0_22) AT=560.1n

* CHECK dout0_23 Vdout0_23ck27 = 0 time = 560
.meas tran vdout0_23ck27 FIND v(dout0_23) AT=560.1n

* CHECK dout0_24 Vdout0_24ck27 = 1.8 time = 560
.meas tran vdout0_24ck27 FIND v(dout0_24) AT=560.1n

* CHECK dout0_25 Vdout0_25ck27 = 0 time = 560
.meas tran vdout0_25ck27 FIND v(dout0_25) AT=560.1n

* CHECK dout0_26 Vdout0_26ck27 = 0 time = 560
.meas tran vdout0_26ck27 FIND v(dout0_26) AT=560.1n

* CHECK dout0_27 Vdout0_27ck27 = 0 time = 560
.meas tran vdout0_27ck27 FIND v(dout0_27) AT=560.1n

* CHECK dout0_28 Vdout0_28ck27 = 1.8 time = 560
.meas tran vdout0_28ck27 FIND v(dout0_28) AT=560.1n

* CHECK dout0_29 Vdout0_29ck27 = 0 time = 560
.meas tran vdout0_29ck27 FIND v(dout0_29) AT=560.1n

* CHECK dout0_30 Vdout0_30ck27 = 1.8 time = 560
.meas tran vdout0_30ck27 FIND v(dout0_30) AT=560.1n

* CHECK dout0_31 Vdout0_31ck27 = 1.8 time = 560
.meas tran vdout0_31ck27 FIND v(dout0_31) AT=560.1n

* CHECK dout0_0 Vdout0_0ck28 = 0 time = 580
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=580.1n

* CHECK dout0_1 Vdout0_1ck28 = 0 time = 580
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=580.1n

* CHECK dout0_2 Vdout0_2ck28 = 0 time = 580
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=580.1n

* CHECK dout0_3 Vdout0_3ck28 = 0 time = 580
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=580.1n

* CHECK dout0_4 Vdout0_4ck28 = 1.8 time = 580
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=580.1n

* CHECK dout0_5 Vdout0_5ck28 = 0 time = 580
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=580.1n

* CHECK dout0_6 Vdout0_6ck28 = 0 time = 580
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=580.1n

* CHECK dout0_7 Vdout0_7ck28 = 0 time = 580
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=580.1n

* CHECK dout0_8 Vdout0_8ck28 = 1.8 time = 580
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=580.1n

* CHECK dout0_9 Vdout0_9ck28 = 0 time = 580
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=580.1n

* CHECK dout0_10 Vdout0_10ck28 = 0 time = 580
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=580.1n

* CHECK dout0_11 Vdout0_11ck28 = 1.8 time = 580
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=580.1n

* CHECK dout0_12 Vdout0_12ck28 = 0 time = 580
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=580.1n

* CHECK dout0_13 Vdout0_13ck28 = 0 time = 580
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=580.1n

* CHECK dout0_14 Vdout0_14ck28 = 1.8 time = 580
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=580.1n

* CHECK dout0_15 Vdout0_15ck28 = 1.8 time = 580
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=580.1n

* CHECK dout0_16 Vdout0_16ck28 = 1.8 time = 580
.meas tran vdout0_16ck28 FIND v(dout0_16) AT=580.1n

* CHECK dout0_17 Vdout0_17ck28 = 1.8 time = 580
.meas tran vdout0_17ck28 FIND v(dout0_17) AT=580.1n

* CHECK dout0_18 Vdout0_18ck28 = 1.8 time = 580
.meas tran vdout0_18ck28 FIND v(dout0_18) AT=580.1n

* CHECK dout0_19 Vdout0_19ck28 = 1.8 time = 580
.meas tran vdout0_19ck28 FIND v(dout0_19) AT=580.1n

* CHECK dout0_20 Vdout0_20ck28 = 0 time = 580
.meas tran vdout0_20ck28 FIND v(dout0_20) AT=580.1n

* CHECK dout0_21 Vdout0_21ck28 = 1.8 time = 580
.meas tran vdout0_21ck28 FIND v(dout0_21) AT=580.1n

* CHECK dout0_22 Vdout0_22ck28 = 1.8 time = 580
.meas tran vdout0_22ck28 FIND v(dout0_22) AT=580.1n

* CHECK dout0_23 Vdout0_23ck28 = 1.8 time = 580
.meas tran vdout0_23ck28 FIND v(dout0_23) AT=580.1n

* CHECK dout0_24 Vdout0_24ck28 = 1.8 time = 580
.meas tran vdout0_24ck28 FIND v(dout0_24) AT=580.1n

* CHECK dout0_25 Vdout0_25ck28 = 0 time = 580
.meas tran vdout0_25ck28 FIND v(dout0_25) AT=580.1n

* CHECK dout0_26 Vdout0_26ck28 = 1.8 time = 580
.meas tran vdout0_26ck28 FIND v(dout0_26) AT=580.1n

* CHECK dout0_27 Vdout0_27ck28 = 1.8 time = 580
.meas tran vdout0_27ck28 FIND v(dout0_27) AT=580.1n

* CHECK dout0_28 Vdout0_28ck28 = 0 time = 580
.meas tran vdout0_28ck28 FIND v(dout0_28) AT=580.1n

* CHECK dout0_29 Vdout0_29ck28 = 0 time = 580
.meas tran vdout0_29ck28 FIND v(dout0_29) AT=580.1n

* CHECK dout0_30 Vdout0_30ck28 = 0 time = 580
.meas tran vdout0_30ck28 FIND v(dout0_30) AT=580.1n

* CHECK dout0_31 Vdout0_31ck28 = 1.8 time = 580
.meas tran vdout0_31ck28 FIND v(dout0_31) AT=580.1n

* CHECK dout0_0 Vdout0_0ck29 = 0 time = 600
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=600.1n

* CHECK dout0_1 Vdout0_1ck29 = 0 time = 600
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=600.1n

* CHECK dout0_2 Vdout0_2ck29 = 0 time = 600
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=600.1n

* CHECK dout0_3 Vdout0_3ck29 = 0 time = 600
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=600.1n

* CHECK dout0_4 Vdout0_4ck29 = 1.8 time = 600
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=600.1n

* CHECK dout0_5 Vdout0_5ck29 = 0 time = 600
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=600.1n

* CHECK dout0_6 Vdout0_6ck29 = 0 time = 600
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=600.1n

* CHECK dout0_7 Vdout0_7ck29 = 0 time = 600
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=600.1n

* CHECK dout0_8 Vdout0_8ck29 = 1.8 time = 600
.meas tran vdout0_8ck29 FIND v(dout0_8) AT=600.1n

* CHECK dout0_9 Vdout0_9ck29 = 0 time = 600
.meas tran vdout0_9ck29 FIND v(dout0_9) AT=600.1n

* CHECK dout0_10 Vdout0_10ck29 = 0 time = 600
.meas tran vdout0_10ck29 FIND v(dout0_10) AT=600.1n

* CHECK dout0_11 Vdout0_11ck29 = 1.8 time = 600
.meas tran vdout0_11ck29 FIND v(dout0_11) AT=600.1n

* CHECK dout0_12 Vdout0_12ck29 = 0 time = 600
.meas tran vdout0_12ck29 FIND v(dout0_12) AT=600.1n

* CHECK dout0_13 Vdout0_13ck29 = 0 time = 600
.meas tran vdout0_13ck29 FIND v(dout0_13) AT=600.1n

* CHECK dout0_14 Vdout0_14ck29 = 1.8 time = 600
.meas tran vdout0_14ck29 FIND v(dout0_14) AT=600.1n

* CHECK dout0_15 Vdout0_15ck29 = 1.8 time = 600
.meas tran vdout0_15ck29 FIND v(dout0_15) AT=600.1n

* CHECK dout0_16 Vdout0_16ck29 = 1.8 time = 600
.meas tran vdout0_16ck29 FIND v(dout0_16) AT=600.1n

* CHECK dout0_17 Vdout0_17ck29 = 1.8 time = 600
.meas tran vdout0_17ck29 FIND v(dout0_17) AT=600.1n

* CHECK dout0_18 Vdout0_18ck29 = 1.8 time = 600
.meas tran vdout0_18ck29 FIND v(dout0_18) AT=600.1n

* CHECK dout0_19 Vdout0_19ck29 = 1.8 time = 600
.meas tran vdout0_19ck29 FIND v(dout0_19) AT=600.1n

* CHECK dout0_20 Vdout0_20ck29 = 0 time = 600
.meas tran vdout0_20ck29 FIND v(dout0_20) AT=600.1n

* CHECK dout0_21 Vdout0_21ck29 = 1.8 time = 600
.meas tran vdout0_21ck29 FIND v(dout0_21) AT=600.1n

* CHECK dout0_22 Vdout0_22ck29 = 1.8 time = 600
.meas tran vdout0_22ck29 FIND v(dout0_22) AT=600.1n

* CHECK dout0_23 Vdout0_23ck29 = 1.8 time = 600
.meas tran vdout0_23ck29 FIND v(dout0_23) AT=600.1n

* CHECK dout0_24 Vdout0_24ck29 = 1.8 time = 600
.meas tran vdout0_24ck29 FIND v(dout0_24) AT=600.1n

* CHECK dout0_25 Vdout0_25ck29 = 0 time = 600
.meas tran vdout0_25ck29 FIND v(dout0_25) AT=600.1n

* CHECK dout0_26 Vdout0_26ck29 = 1.8 time = 600
.meas tran vdout0_26ck29 FIND v(dout0_26) AT=600.1n

* CHECK dout0_27 Vdout0_27ck29 = 1.8 time = 600
.meas tran vdout0_27ck29 FIND v(dout0_27) AT=600.1n

* CHECK dout0_28 Vdout0_28ck29 = 0 time = 600
.meas tran vdout0_28ck29 FIND v(dout0_28) AT=600.1n

* CHECK dout0_29 Vdout0_29ck29 = 0 time = 600
.meas tran vdout0_29ck29 FIND v(dout0_29) AT=600.1n

* CHECK dout0_30 Vdout0_30ck29 = 0 time = 600
.meas tran vdout0_30ck29 FIND v(dout0_30) AT=600.1n

* CHECK dout0_31 Vdout0_31ck29 = 1.8 time = 600
.meas tran vdout0_31ck29 FIND v(dout0_31) AT=600.1n

* CHECK dout0_0 Vdout0_0ck30 = 1.8 time = 620
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=620.1n

* CHECK dout0_1 Vdout0_1ck30 = 1.8 time = 620
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=620.1n

* CHECK dout0_2 Vdout0_2ck30 = 1.8 time = 620
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=620.1n

* CHECK dout0_3 Vdout0_3ck30 = 0 time = 620
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=620.1n

* CHECK dout0_4 Vdout0_4ck30 = 0 time = 620
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=620.1n

* CHECK dout0_5 Vdout0_5ck30 = 1.8 time = 620
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=620.1n

* CHECK dout0_6 Vdout0_6ck30 = 0 time = 620
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=620.1n

* CHECK dout0_7 Vdout0_7ck30 = 0 time = 620
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=620.1n

* CHECK dout0_8 Vdout0_8ck30 = 0 time = 620
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=620.1n

* CHECK dout0_9 Vdout0_9ck30 = 0 time = 620
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=620.1n

* CHECK dout0_10 Vdout0_10ck30 = 0 time = 620
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=620.1n

* CHECK dout0_11 Vdout0_11ck30 = 0 time = 620
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=620.1n

* CHECK dout0_12 Vdout0_12ck30 = 1.8 time = 620
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=620.1n

* CHECK dout0_13 Vdout0_13ck30 = 0 time = 620
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=620.1n

* CHECK dout0_14 Vdout0_14ck30 = 1.8 time = 620
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=620.1n

* CHECK dout0_15 Vdout0_15ck30 = 0 time = 620
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=620.1n

* CHECK dout0_16 Vdout0_16ck30 = 1.8 time = 620
.meas tran vdout0_16ck30 FIND v(dout0_16) AT=620.1n

* CHECK dout0_17 Vdout0_17ck30 = 0 time = 620
.meas tran vdout0_17ck30 FIND v(dout0_17) AT=620.1n

* CHECK dout0_18 Vdout0_18ck30 = 1.8 time = 620
.meas tran vdout0_18ck30 FIND v(dout0_18) AT=620.1n

* CHECK dout0_19 Vdout0_19ck30 = 1.8 time = 620
.meas tran vdout0_19ck30 FIND v(dout0_19) AT=620.1n

* CHECK dout0_20 Vdout0_20ck30 = 1.8 time = 620
.meas tran vdout0_20ck30 FIND v(dout0_20) AT=620.1n

* CHECK dout0_21 Vdout0_21ck30 = 1.8 time = 620
.meas tran vdout0_21ck30 FIND v(dout0_21) AT=620.1n

* CHECK dout0_22 Vdout0_22ck30 = 0 time = 620
.meas tran vdout0_22ck30 FIND v(dout0_22) AT=620.1n

* CHECK dout0_23 Vdout0_23ck30 = 0 time = 620
.meas tran vdout0_23ck30 FIND v(dout0_23) AT=620.1n

* CHECK dout0_24 Vdout0_24ck30 = 1.8 time = 620
.meas tran vdout0_24ck30 FIND v(dout0_24) AT=620.1n

* CHECK dout0_25 Vdout0_25ck30 = 0 time = 620
.meas tran vdout0_25ck30 FIND v(dout0_25) AT=620.1n

* CHECK dout0_26 Vdout0_26ck30 = 0 time = 620
.meas tran vdout0_26ck30 FIND v(dout0_26) AT=620.1n

* CHECK dout0_27 Vdout0_27ck30 = 1.8 time = 620
.meas tran vdout0_27ck30 FIND v(dout0_27) AT=620.1n

* CHECK dout0_28 Vdout0_28ck30 = 1.8 time = 620
.meas tran vdout0_28ck30 FIND v(dout0_28) AT=620.1n

* CHECK dout0_29 Vdout0_29ck30 = 0 time = 620
.meas tran vdout0_29ck30 FIND v(dout0_29) AT=620.1n

* CHECK dout0_30 Vdout0_30ck30 = 1.8 time = 620
.meas tran vdout0_30ck30 FIND v(dout0_30) AT=620.1n

* CHECK dout0_31 Vdout0_31ck30 = 1.8 time = 620
.meas tran vdout0_31ck30 FIND v(dout0_31) AT=620.1n

* CHECK dout0_0 Vdout0_0ck31 = 1.8 time = 640
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=640.1n

* CHECK dout0_1 Vdout0_1ck31 = 1.8 time = 640
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=640.1n

* CHECK dout0_2 Vdout0_2ck31 = 1.8 time = 640
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=640.1n

* CHECK dout0_3 Vdout0_3ck31 = 0 time = 640
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=640.1n

* CHECK dout0_4 Vdout0_4ck31 = 0 time = 640
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=640.1n

* CHECK dout0_5 Vdout0_5ck31 = 1.8 time = 640
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=640.1n

* CHECK dout0_6 Vdout0_6ck31 = 0 time = 640
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=640.1n

* CHECK dout0_7 Vdout0_7ck31 = 0 time = 640
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=640.1n

* CHECK dout0_8 Vdout0_8ck31 = 0 time = 640
.meas tran vdout0_8ck31 FIND v(dout0_8) AT=640.1n

* CHECK dout0_9 Vdout0_9ck31 = 0 time = 640
.meas tran vdout0_9ck31 FIND v(dout0_9) AT=640.1n

* CHECK dout0_10 Vdout0_10ck31 = 0 time = 640
.meas tran vdout0_10ck31 FIND v(dout0_10) AT=640.1n

* CHECK dout0_11 Vdout0_11ck31 = 0 time = 640
.meas tran vdout0_11ck31 FIND v(dout0_11) AT=640.1n

* CHECK dout0_12 Vdout0_12ck31 = 1.8 time = 640
.meas tran vdout0_12ck31 FIND v(dout0_12) AT=640.1n

* CHECK dout0_13 Vdout0_13ck31 = 0 time = 640
.meas tran vdout0_13ck31 FIND v(dout0_13) AT=640.1n

* CHECK dout0_14 Vdout0_14ck31 = 1.8 time = 640
.meas tran vdout0_14ck31 FIND v(dout0_14) AT=640.1n

* CHECK dout0_15 Vdout0_15ck31 = 0 time = 640
.meas tran vdout0_15ck31 FIND v(dout0_15) AT=640.1n

* CHECK dout0_16 Vdout0_16ck31 = 1.8 time = 640
.meas tran vdout0_16ck31 FIND v(dout0_16) AT=640.1n

* CHECK dout0_17 Vdout0_17ck31 = 0 time = 640
.meas tran vdout0_17ck31 FIND v(dout0_17) AT=640.1n

* CHECK dout0_18 Vdout0_18ck31 = 1.8 time = 640
.meas tran vdout0_18ck31 FIND v(dout0_18) AT=640.1n

* CHECK dout0_19 Vdout0_19ck31 = 1.8 time = 640
.meas tran vdout0_19ck31 FIND v(dout0_19) AT=640.1n

* CHECK dout0_20 Vdout0_20ck31 = 1.8 time = 640
.meas tran vdout0_20ck31 FIND v(dout0_20) AT=640.1n

* CHECK dout0_21 Vdout0_21ck31 = 1.8 time = 640
.meas tran vdout0_21ck31 FIND v(dout0_21) AT=640.1n

* CHECK dout0_22 Vdout0_22ck31 = 0 time = 640
.meas tran vdout0_22ck31 FIND v(dout0_22) AT=640.1n

* CHECK dout0_23 Vdout0_23ck31 = 0 time = 640
.meas tran vdout0_23ck31 FIND v(dout0_23) AT=640.1n

* CHECK dout0_24 Vdout0_24ck31 = 1.8 time = 640
.meas tran vdout0_24ck31 FIND v(dout0_24) AT=640.1n

* CHECK dout0_25 Vdout0_25ck31 = 0 time = 640
.meas tran vdout0_25ck31 FIND v(dout0_25) AT=640.1n

* CHECK dout0_26 Vdout0_26ck31 = 0 time = 640
.meas tran vdout0_26ck31 FIND v(dout0_26) AT=640.1n

* CHECK dout0_27 Vdout0_27ck31 = 1.8 time = 640
.meas tran vdout0_27ck31 FIND v(dout0_27) AT=640.1n

* CHECK dout0_28 Vdout0_28ck31 = 1.8 time = 640
.meas tran vdout0_28ck31 FIND v(dout0_28) AT=640.1n

* CHECK dout0_29 Vdout0_29ck31 = 0 time = 640
.meas tran vdout0_29ck31 FIND v(dout0_29) AT=640.1n

* CHECK dout0_30 Vdout0_30ck31 = 1.8 time = 640
.meas tran vdout0_30ck31 FIND v(dout0_30) AT=640.1n

* CHECK dout0_31 Vdout0_31ck31 = 1.8 time = 640
.meas tran vdout0_31ck31 FIND v(dout0_31) AT=640.1n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 680
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=680.1n

* CHECK dout0_1 Vdout0_1ck33 = 1.8 time = 680
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=680.1n

* CHECK dout0_2 Vdout0_2ck33 = 1.8 time = 680
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=680.1n

* CHECK dout0_3 Vdout0_3ck33 = 1.8 time = 680
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=680.1n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 680
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=680.1n

* CHECK dout0_5 Vdout0_5ck33 = 1.8 time = 680
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=680.1n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 680
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=680.1n

* CHECK dout0_7 Vdout0_7ck33 = 1.8 time = 680
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=680.1n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 680
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=680.1n

* CHECK dout0_9 Vdout0_9ck33 = 1.8 time = 680
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=680.1n

* CHECK dout0_10 Vdout0_10ck33 = 1.8 time = 680
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=680.1n

* CHECK dout0_11 Vdout0_11ck33 = 1.8 time = 680
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=680.1n

* CHECK dout0_12 Vdout0_12ck33 = 0 time = 680
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=680.1n

* CHECK dout0_13 Vdout0_13ck33 = 0 time = 680
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=680.1n

* CHECK dout0_14 Vdout0_14ck33 = 0 time = 680
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=680.1n

* CHECK dout0_15 Vdout0_15ck33 = 0 time = 680
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=680.1n

* CHECK dout0_16 Vdout0_16ck33 = 0 time = 680
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=680.1n

* CHECK dout0_17 Vdout0_17ck33 = 0 time = 680
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=680.1n

* CHECK dout0_18 Vdout0_18ck33 = 0 time = 680
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=680.1n

* CHECK dout0_19 Vdout0_19ck33 = 0 time = 680
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=680.1n

* CHECK dout0_20 Vdout0_20ck33 = 1.8 time = 680
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=680.1n

* CHECK dout0_21 Vdout0_21ck33 = 1.8 time = 680
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=680.1n

* CHECK dout0_22 Vdout0_22ck33 = 0 time = 680
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=680.1n

* CHECK dout0_23 Vdout0_23ck33 = 1.8 time = 680
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=680.1n

* CHECK dout0_24 Vdout0_24ck33 = 1.8 time = 680
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=680.1n

* CHECK dout0_25 Vdout0_25ck33 = 0 time = 680
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=680.1n

* CHECK dout0_26 Vdout0_26ck33 = 0 time = 680
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=680.1n

* CHECK dout0_27 Vdout0_27ck33 = 0 time = 680
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=680.1n

* CHECK dout0_28 Vdout0_28ck33 = 1.8 time = 680
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=680.1n

* CHECK dout0_29 Vdout0_29ck33 = 0 time = 680
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=680.1n

* CHECK dout0_30 Vdout0_30ck33 = 0 time = 680
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=680.1n

* CHECK dout0_31 Vdout0_31ck33 = 1.8 time = 680
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=680.1n

* CHECK dout0_0 Vdout0_0ck39 = 0 time = 800
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=800.1n

* CHECK dout0_1 Vdout0_1ck39 = 0 time = 800
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=800.1n

* CHECK dout0_2 Vdout0_2ck39 = 0 time = 800
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=800.1n

* CHECK dout0_3 Vdout0_3ck39 = 0 time = 800
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=800.1n

* CHECK dout0_4 Vdout0_4ck39 = 1.8 time = 800
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=800.1n

* CHECK dout0_5 Vdout0_5ck39 = 0 time = 800
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=800.1n

* CHECK dout0_6 Vdout0_6ck39 = 0 time = 800
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=800.1n

* CHECK dout0_7 Vdout0_7ck39 = 0 time = 800
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=800.1n

* CHECK dout0_8 Vdout0_8ck39 = 1.8 time = 800
.meas tran vdout0_8ck39 FIND v(dout0_8) AT=800.1n

* CHECK dout0_9 Vdout0_9ck39 = 0 time = 800
.meas tran vdout0_9ck39 FIND v(dout0_9) AT=800.1n

* CHECK dout0_10 Vdout0_10ck39 = 0 time = 800
.meas tran vdout0_10ck39 FIND v(dout0_10) AT=800.1n

* CHECK dout0_11 Vdout0_11ck39 = 1.8 time = 800
.meas tran vdout0_11ck39 FIND v(dout0_11) AT=800.1n

* CHECK dout0_12 Vdout0_12ck39 = 0 time = 800
.meas tran vdout0_12ck39 FIND v(dout0_12) AT=800.1n

* CHECK dout0_13 Vdout0_13ck39 = 0 time = 800
.meas tran vdout0_13ck39 FIND v(dout0_13) AT=800.1n

* CHECK dout0_14 Vdout0_14ck39 = 1.8 time = 800
.meas tran vdout0_14ck39 FIND v(dout0_14) AT=800.1n

* CHECK dout0_15 Vdout0_15ck39 = 1.8 time = 800
.meas tran vdout0_15ck39 FIND v(dout0_15) AT=800.1n

* CHECK dout0_16 Vdout0_16ck39 = 1.8 time = 800
.meas tran vdout0_16ck39 FIND v(dout0_16) AT=800.1n

* CHECK dout0_17 Vdout0_17ck39 = 1.8 time = 800
.meas tran vdout0_17ck39 FIND v(dout0_17) AT=800.1n

* CHECK dout0_18 Vdout0_18ck39 = 1.8 time = 800
.meas tran vdout0_18ck39 FIND v(dout0_18) AT=800.1n

* CHECK dout0_19 Vdout0_19ck39 = 1.8 time = 800
.meas tran vdout0_19ck39 FIND v(dout0_19) AT=800.1n

* CHECK dout0_20 Vdout0_20ck39 = 0 time = 800
.meas tran vdout0_20ck39 FIND v(dout0_20) AT=800.1n

* CHECK dout0_21 Vdout0_21ck39 = 1.8 time = 800
.meas tran vdout0_21ck39 FIND v(dout0_21) AT=800.1n

* CHECK dout0_22 Vdout0_22ck39 = 1.8 time = 800
.meas tran vdout0_22ck39 FIND v(dout0_22) AT=800.1n

* CHECK dout0_23 Vdout0_23ck39 = 1.8 time = 800
.meas tran vdout0_23ck39 FIND v(dout0_23) AT=800.1n

* CHECK dout0_24 Vdout0_24ck39 = 1.8 time = 800
.meas tran vdout0_24ck39 FIND v(dout0_24) AT=800.1n

* CHECK dout0_25 Vdout0_25ck39 = 0 time = 800
.meas tran vdout0_25ck39 FIND v(dout0_25) AT=800.1n

* CHECK dout0_26 Vdout0_26ck39 = 1.8 time = 800
.meas tran vdout0_26ck39 FIND v(dout0_26) AT=800.1n

* CHECK dout0_27 Vdout0_27ck39 = 1.8 time = 800
.meas tran vdout0_27ck39 FIND v(dout0_27) AT=800.1n

* CHECK dout0_28 Vdout0_28ck39 = 0 time = 800
.meas tran vdout0_28ck39 FIND v(dout0_28) AT=800.1n

* CHECK dout0_29 Vdout0_29ck39 = 0 time = 800
.meas tran vdout0_29ck39 FIND v(dout0_29) AT=800.1n

* CHECK dout0_30 Vdout0_30ck39 = 0 time = 800
.meas tran vdout0_30ck39 FIND v(dout0_30) AT=800.1n

* CHECK dout0_31 Vdout0_31ck39 = 1.8 time = 800
.meas tran vdout0_31ck39 FIND v(dout0_31) AT=800.1n

* CHECK dout0_0 Vdout0_0ck41 = 0 time = 840
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=840.1n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 840
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=840.1n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 840
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=840.1n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 840
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=840.1n

* CHECK dout0_4 Vdout0_4ck41 = 1.8 time = 840
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=840.1n

* CHECK dout0_5 Vdout0_5ck41 = 0 time = 840
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=840.1n

* CHECK dout0_6 Vdout0_6ck41 = 0 time = 840
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=840.1n

* CHECK dout0_7 Vdout0_7ck41 = 0 time = 840
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=840.1n

* CHECK dout0_8 Vdout0_8ck41 = 1.8 time = 840
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=840.1n

* CHECK dout0_9 Vdout0_9ck41 = 0 time = 840
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=840.1n

* CHECK dout0_10 Vdout0_10ck41 = 0 time = 840
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=840.1n

* CHECK dout0_11 Vdout0_11ck41 = 1.8 time = 840
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=840.1n

* CHECK dout0_12 Vdout0_12ck41 = 0 time = 840
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=840.1n

* CHECK dout0_13 Vdout0_13ck41 = 0 time = 840
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=840.1n

* CHECK dout0_14 Vdout0_14ck41 = 1.8 time = 840
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=840.1n

* CHECK dout0_15 Vdout0_15ck41 = 1.8 time = 840
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=840.1n

* CHECK dout0_16 Vdout0_16ck41 = 1.8 time = 840
.meas tran vdout0_16ck41 FIND v(dout0_16) AT=840.1n

* CHECK dout0_17 Vdout0_17ck41 = 1.8 time = 840
.meas tran vdout0_17ck41 FIND v(dout0_17) AT=840.1n

* CHECK dout0_18 Vdout0_18ck41 = 1.8 time = 840
.meas tran vdout0_18ck41 FIND v(dout0_18) AT=840.1n

* CHECK dout0_19 Vdout0_19ck41 = 1.8 time = 840
.meas tran vdout0_19ck41 FIND v(dout0_19) AT=840.1n

* CHECK dout0_20 Vdout0_20ck41 = 0 time = 840
.meas tran vdout0_20ck41 FIND v(dout0_20) AT=840.1n

* CHECK dout0_21 Vdout0_21ck41 = 1.8 time = 840
.meas tran vdout0_21ck41 FIND v(dout0_21) AT=840.1n

* CHECK dout0_22 Vdout0_22ck41 = 1.8 time = 840
.meas tran vdout0_22ck41 FIND v(dout0_22) AT=840.1n

* CHECK dout0_23 Vdout0_23ck41 = 1.8 time = 840
.meas tran vdout0_23ck41 FIND v(dout0_23) AT=840.1n

* CHECK dout0_24 Vdout0_24ck41 = 1.8 time = 840
.meas tran vdout0_24ck41 FIND v(dout0_24) AT=840.1n

* CHECK dout0_25 Vdout0_25ck41 = 0 time = 840
.meas tran vdout0_25ck41 FIND v(dout0_25) AT=840.1n

* CHECK dout0_26 Vdout0_26ck41 = 1.8 time = 840
.meas tran vdout0_26ck41 FIND v(dout0_26) AT=840.1n

* CHECK dout0_27 Vdout0_27ck41 = 1.8 time = 840
.meas tran vdout0_27ck41 FIND v(dout0_27) AT=840.1n

* CHECK dout0_28 Vdout0_28ck41 = 0 time = 840
.meas tran vdout0_28ck41 FIND v(dout0_28) AT=840.1n

* CHECK dout0_29 Vdout0_29ck41 = 0 time = 840
.meas tran vdout0_29ck41 FIND v(dout0_29) AT=840.1n

* CHECK dout0_30 Vdout0_30ck41 = 0 time = 840
.meas tran vdout0_30ck41 FIND v(dout0_30) AT=840.1n

* CHECK dout0_31 Vdout0_31ck41 = 1.8 time = 840
.meas tran vdout0_31ck41 FIND v(dout0_31) AT=840.1n

* CHECK dout0_0 Vdout0_0ck42 = 1.8 time = 860
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=860.1n

* CHECK dout0_1 Vdout0_1ck42 = 1.8 time = 860
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=860.1n

* CHECK dout0_2 Vdout0_2ck42 = 1.8 time = 860
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=860.1n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 860
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=860.1n

* CHECK dout0_4 Vdout0_4ck42 = 0 time = 860
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=860.1n

* CHECK dout0_5 Vdout0_5ck42 = 1.8 time = 860
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=860.1n

* CHECK dout0_6 Vdout0_6ck42 = 0 time = 860
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=860.1n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 860
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=860.1n

* CHECK dout0_8 Vdout0_8ck42 = 0 time = 860
.meas tran vdout0_8ck42 FIND v(dout0_8) AT=860.1n

* CHECK dout0_9 Vdout0_9ck42 = 0 time = 860
.meas tran vdout0_9ck42 FIND v(dout0_9) AT=860.1n

* CHECK dout0_10 Vdout0_10ck42 = 0 time = 860
.meas tran vdout0_10ck42 FIND v(dout0_10) AT=860.1n

* CHECK dout0_11 Vdout0_11ck42 = 0 time = 860
.meas tran vdout0_11ck42 FIND v(dout0_11) AT=860.1n

* CHECK dout0_12 Vdout0_12ck42 = 1.8 time = 860
.meas tran vdout0_12ck42 FIND v(dout0_12) AT=860.1n

* CHECK dout0_13 Vdout0_13ck42 = 0 time = 860
.meas tran vdout0_13ck42 FIND v(dout0_13) AT=860.1n

* CHECK dout0_14 Vdout0_14ck42 = 1.8 time = 860
.meas tran vdout0_14ck42 FIND v(dout0_14) AT=860.1n

* CHECK dout0_15 Vdout0_15ck42 = 0 time = 860
.meas tran vdout0_15ck42 FIND v(dout0_15) AT=860.1n

* CHECK dout0_16 Vdout0_16ck42 = 1.8 time = 860
.meas tran vdout0_16ck42 FIND v(dout0_16) AT=860.1n

* CHECK dout0_17 Vdout0_17ck42 = 0 time = 860
.meas tran vdout0_17ck42 FIND v(dout0_17) AT=860.1n

* CHECK dout0_18 Vdout0_18ck42 = 1.8 time = 860
.meas tran vdout0_18ck42 FIND v(dout0_18) AT=860.1n

* CHECK dout0_19 Vdout0_19ck42 = 1.8 time = 860
.meas tran vdout0_19ck42 FIND v(dout0_19) AT=860.1n

* CHECK dout0_20 Vdout0_20ck42 = 1.8 time = 860
.meas tran vdout0_20ck42 FIND v(dout0_20) AT=860.1n

* CHECK dout0_21 Vdout0_21ck42 = 1.8 time = 860
.meas tran vdout0_21ck42 FIND v(dout0_21) AT=860.1n

* CHECK dout0_22 Vdout0_22ck42 = 0 time = 860
.meas tran vdout0_22ck42 FIND v(dout0_22) AT=860.1n

* CHECK dout0_23 Vdout0_23ck42 = 0 time = 860
.meas tran vdout0_23ck42 FIND v(dout0_23) AT=860.1n

* CHECK dout0_24 Vdout0_24ck42 = 1.8 time = 860
.meas tran vdout0_24ck42 FIND v(dout0_24) AT=860.1n

* CHECK dout0_25 Vdout0_25ck42 = 0 time = 860
.meas tran vdout0_25ck42 FIND v(dout0_25) AT=860.1n

* CHECK dout0_26 Vdout0_26ck42 = 0 time = 860
.meas tran vdout0_26ck42 FIND v(dout0_26) AT=860.1n

* CHECK dout0_27 Vdout0_27ck42 = 1.8 time = 860
.meas tran vdout0_27ck42 FIND v(dout0_27) AT=860.1n

* CHECK dout0_28 Vdout0_28ck42 = 1.8 time = 860
.meas tran vdout0_28ck42 FIND v(dout0_28) AT=860.1n

* CHECK dout0_29 Vdout0_29ck42 = 0 time = 860
.meas tran vdout0_29ck42 FIND v(dout0_29) AT=860.1n

* CHECK dout0_30 Vdout0_30ck42 = 1.8 time = 860
.meas tran vdout0_30ck42 FIND v(dout0_30) AT=860.1n

* CHECK dout0_31 Vdout0_31ck42 = 1.8 time = 860
.meas tran vdout0_31ck42 FIND v(dout0_31) AT=860.1n

* CHECK dout0_0 Vdout0_0ck44 = 1.8 time = 900
.meas tran vdout0_0ck44 FIND v(dout0_0) AT=900.1n

* CHECK dout0_1 Vdout0_1ck44 = 0 time = 900
.meas tran vdout0_1ck44 FIND v(dout0_1) AT=900.1n

* CHECK dout0_2 Vdout0_2ck44 = 1.8 time = 900
.meas tran vdout0_2ck44 FIND v(dout0_2) AT=900.1n

* CHECK dout0_3 Vdout0_3ck44 = 0 time = 900
.meas tran vdout0_3ck44 FIND v(dout0_3) AT=900.1n

* CHECK dout0_4 Vdout0_4ck44 = 0 time = 900
.meas tran vdout0_4ck44 FIND v(dout0_4) AT=900.1n

* CHECK dout0_5 Vdout0_5ck44 = 1.8 time = 900
.meas tran vdout0_5ck44 FIND v(dout0_5) AT=900.1n

* CHECK dout0_6 Vdout0_6ck44 = 1.8 time = 900
.meas tran vdout0_6ck44 FIND v(dout0_6) AT=900.1n

* CHECK dout0_7 Vdout0_7ck44 = 0 time = 900
.meas tran vdout0_7ck44 FIND v(dout0_7) AT=900.1n

* CHECK dout0_8 Vdout0_8ck44 = 0 time = 900
.meas tran vdout0_8ck44 FIND v(dout0_8) AT=900.1n

* CHECK dout0_9 Vdout0_9ck44 = 0 time = 900
.meas tran vdout0_9ck44 FIND v(dout0_9) AT=900.1n

* CHECK dout0_10 Vdout0_10ck44 = 1.8 time = 900
.meas tran vdout0_10ck44 FIND v(dout0_10) AT=900.1n

* CHECK dout0_11 Vdout0_11ck44 = 0 time = 900
.meas tran vdout0_11ck44 FIND v(dout0_11) AT=900.1n

* CHECK dout0_12 Vdout0_12ck44 = 0 time = 900
.meas tran vdout0_12ck44 FIND v(dout0_12) AT=900.1n

* CHECK dout0_13 Vdout0_13ck44 = 0 time = 900
.meas tran vdout0_13ck44 FIND v(dout0_13) AT=900.1n

* CHECK dout0_14 Vdout0_14ck44 = 0 time = 900
.meas tran vdout0_14ck44 FIND v(dout0_14) AT=900.1n

* CHECK dout0_15 Vdout0_15ck44 = 1.8 time = 900
.meas tran vdout0_15ck44 FIND v(dout0_15) AT=900.1n

* CHECK dout0_16 Vdout0_16ck44 = 1.8 time = 900
.meas tran vdout0_16ck44 FIND v(dout0_16) AT=900.1n

* CHECK dout0_17 Vdout0_17ck44 = 0 time = 900
.meas tran vdout0_17ck44 FIND v(dout0_17) AT=900.1n

* CHECK dout0_18 Vdout0_18ck44 = 1.8 time = 900
.meas tran vdout0_18ck44 FIND v(dout0_18) AT=900.1n

* CHECK dout0_19 Vdout0_19ck44 = 1.8 time = 900
.meas tran vdout0_19ck44 FIND v(dout0_19) AT=900.1n

* CHECK dout0_20 Vdout0_20ck44 = 1.8 time = 900
.meas tran vdout0_20ck44 FIND v(dout0_20) AT=900.1n

* CHECK dout0_21 Vdout0_21ck44 = 0 time = 900
.meas tran vdout0_21ck44 FIND v(dout0_21) AT=900.1n

* CHECK dout0_22 Vdout0_22ck44 = 1.8 time = 900
.meas tran vdout0_22ck44 FIND v(dout0_22) AT=900.1n

* CHECK dout0_23 Vdout0_23ck44 = 0 time = 900
.meas tran vdout0_23ck44 FIND v(dout0_23) AT=900.1n

* CHECK dout0_24 Vdout0_24ck44 = 1.8 time = 900
.meas tran vdout0_24ck44 FIND v(dout0_24) AT=900.1n

* CHECK dout0_25 Vdout0_25ck44 = 1.8 time = 900
.meas tran vdout0_25ck44 FIND v(dout0_25) AT=900.1n

* CHECK dout0_26 Vdout0_26ck44 = 1.8 time = 900
.meas tran vdout0_26ck44 FIND v(dout0_26) AT=900.1n

* CHECK dout0_27 Vdout0_27ck44 = 0 time = 900
.meas tran vdout0_27ck44 FIND v(dout0_27) AT=900.1n

* CHECK dout0_28 Vdout0_28ck44 = 1.8 time = 900
.meas tran vdout0_28ck44 FIND v(dout0_28) AT=900.1n

* CHECK dout0_29 Vdout0_29ck44 = 0 time = 900
.meas tran vdout0_29ck44 FIND v(dout0_29) AT=900.1n

* CHECK dout0_30 Vdout0_30ck44 = 0 time = 900
.meas tran vdout0_30ck44 FIND v(dout0_30) AT=900.1n

* CHECK dout0_31 Vdout0_31ck44 = 1.8 time = 900
.meas tran vdout0_31ck44 FIND v(dout0_31) AT=900.1n

* CHECK dout0_0 Vdout0_0ck46 = 0 time = 940
.meas tran vdout0_0ck46 FIND v(dout0_0) AT=940.1n

* CHECK dout0_1 Vdout0_1ck46 = 1.8 time = 940
.meas tran vdout0_1ck46 FIND v(dout0_1) AT=940.1n

* CHECK dout0_2 Vdout0_2ck46 = 1.8 time = 940
.meas tran vdout0_2ck46 FIND v(dout0_2) AT=940.1n

* CHECK dout0_3 Vdout0_3ck46 = 1.8 time = 940
.meas tran vdout0_3ck46 FIND v(dout0_3) AT=940.1n

* CHECK dout0_4 Vdout0_4ck46 = 0 time = 940
.meas tran vdout0_4ck46 FIND v(dout0_4) AT=940.1n

* CHECK dout0_5 Vdout0_5ck46 = 1.8 time = 940
.meas tran vdout0_5ck46 FIND v(dout0_5) AT=940.1n

* CHECK dout0_6 Vdout0_6ck46 = 0 time = 940
.meas tran vdout0_6ck46 FIND v(dout0_6) AT=940.1n

* CHECK dout0_7 Vdout0_7ck46 = 1.8 time = 940
.meas tran vdout0_7ck46 FIND v(dout0_7) AT=940.1n

* CHECK dout0_8 Vdout0_8ck46 = 0 time = 940
.meas tran vdout0_8ck46 FIND v(dout0_8) AT=940.1n

* CHECK dout0_9 Vdout0_9ck46 = 1.8 time = 940
.meas tran vdout0_9ck46 FIND v(dout0_9) AT=940.1n

* CHECK dout0_10 Vdout0_10ck46 = 1.8 time = 940
.meas tran vdout0_10ck46 FIND v(dout0_10) AT=940.1n

* CHECK dout0_11 Vdout0_11ck46 = 1.8 time = 940
.meas tran vdout0_11ck46 FIND v(dout0_11) AT=940.1n

* CHECK dout0_12 Vdout0_12ck46 = 0 time = 940
.meas tran vdout0_12ck46 FIND v(dout0_12) AT=940.1n

* CHECK dout0_13 Vdout0_13ck46 = 0 time = 940
.meas tran vdout0_13ck46 FIND v(dout0_13) AT=940.1n

* CHECK dout0_14 Vdout0_14ck46 = 0 time = 940
.meas tran vdout0_14ck46 FIND v(dout0_14) AT=940.1n

* CHECK dout0_15 Vdout0_15ck46 = 0 time = 940
.meas tran vdout0_15ck46 FIND v(dout0_15) AT=940.1n

* CHECK dout0_16 Vdout0_16ck46 = 0 time = 940
.meas tran vdout0_16ck46 FIND v(dout0_16) AT=940.1n

* CHECK dout0_17 Vdout0_17ck46 = 0 time = 940
.meas tran vdout0_17ck46 FIND v(dout0_17) AT=940.1n

* CHECK dout0_18 Vdout0_18ck46 = 0 time = 940
.meas tran vdout0_18ck46 FIND v(dout0_18) AT=940.1n

* CHECK dout0_19 Vdout0_19ck46 = 0 time = 940
.meas tran vdout0_19ck46 FIND v(dout0_19) AT=940.1n

* CHECK dout0_20 Vdout0_20ck46 = 1.8 time = 940
.meas tran vdout0_20ck46 FIND v(dout0_20) AT=940.1n

* CHECK dout0_21 Vdout0_21ck46 = 1.8 time = 940
.meas tran vdout0_21ck46 FIND v(dout0_21) AT=940.1n

* CHECK dout0_22 Vdout0_22ck46 = 0 time = 940
.meas tran vdout0_22ck46 FIND v(dout0_22) AT=940.1n

* CHECK dout0_23 Vdout0_23ck46 = 1.8 time = 940
.meas tran vdout0_23ck46 FIND v(dout0_23) AT=940.1n

* CHECK dout0_24 Vdout0_24ck46 = 1.8 time = 940
.meas tran vdout0_24ck46 FIND v(dout0_24) AT=940.1n

* CHECK dout0_25 Vdout0_25ck46 = 0 time = 940
.meas tran vdout0_25ck46 FIND v(dout0_25) AT=940.1n

* CHECK dout0_26 Vdout0_26ck46 = 0 time = 940
.meas tran vdout0_26ck46 FIND v(dout0_26) AT=940.1n

* CHECK dout0_27 Vdout0_27ck46 = 0 time = 940
.meas tran vdout0_27ck46 FIND v(dout0_27) AT=940.1n

* CHECK dout0_28 Vdout0_28ck46 = 1.8 time = 940
.meas tran vdout0_28ck46 FIND v(dout0_28) AT=940.1n

* CHECK dout0_29 Vdout0_29ck46 = 0 time = 940
.meas tran vdout0_29ck46 FIND v(dout0_29) AT=940.1n

* CHECK dout0_30 Vdout0_30ck46 = 0 time = 940
.meas tran vdout0_30ck46 FIND v(dout0_30) AT=940.1n

* CHECK dout0_31 Vdout0_31ck46 = 1.8 time = 940
.meas tran vdout0_31ck46 FIND v(dout0_31) AT=940.1n

* CHECK dout0_0 Vdout0_0ck47 = 1.8 time = 960
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=960.1n

* CHECK dout0_1 Vdout0_1ck47 = 1.8 time = 960
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=960.1n

* CHECK dout0_2 Vdout0_2ck47 = 1.8 time = 960
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=960.1n

* CHECK dout0_3 Vdout0_3ck47 = 1.8 time = 960
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=960.1n

* CHECK dout0_4 Vdout0_4ck47 = 0 time = 960
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=960.1n

* CHECK dout0_5 Vdout0_5ck47 = 0 time = 960
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=960.1n

* CHECK dout0_6 Vdout0_6ck47 = 1.8 time = 960
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=960.1n

* CHECK dout0_7 Vdout0_7ck47 = 0 time = 960
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=960.1n

* CHECK dout0_8 Vdout0_8ck47 = 0 time = 960
.meas tran vdout0_8ck47 FIND v(dout0_8) AT=960.1n

* CHECK dout0_9 Vdout0_9ck47 = 0 time = 960
.meas tran vdout0_9ck47 FIND v(dout0_9) AT=960.1n

* CHECK dout0_10 Vdout0_10ck47 = 0 time = 960
.meas tran vdout0_10ck47 FIND v(dout0_10) AT=960.1n

* CHECK dout0_11 Vdout0_11ck47 = 1.8 time = 960
.meas tran vdout0_11ck47 FIND v(dout0_11) AT=960.1n

* CHECK dout0_12 Vdout0_12ck47 = 1.8 time = 960
.meas tran vdout0_12ck47 FIND v(dout0_12) AT=960.1n

* CHECK dout0_13 Vdout0_13ck47 = 0 time = 960
.meas tran vdout0_13ck47 FIND v(dout0_13) AT=960.1n

* CHECK dout0_14 Vdout0_14ck47 = 1.8 time = 960
.meas tran vdout0_14ck47 FIND v(dout0_14) AT=960.1n

* CHECK dout0_15 Vdout0_15ck47 = 1.8 time = 960
.meas tran vdout0_15ck47 FIND v(dout0_15) AT=960.1n

* CHECK dout0_16 Vdout0_16ck47 = 1.8 time = 960
.meas tran vdout0_16ck47 FIND v(dout0_16) AT=960.1n

* CHECK dout0_17 Vdout0_17ck47 = 1.8 time = 960
.meas tran vdout0_17ck47 FIND v(dout0_17) AT=960.1n

* CHECK dout0_18 Vdout0_18ck47 = 1.8 time = 960
.meas tran vdout0_18ck47 FIND v(dout0_18) AT=960.1n

* CHECK dout0_19 Vdout0_19ck47 = 0 time = 960
.meas tran vdout0_19ck47 FIND v(dout0_19) AT=960.1n

* CHECK dout0_20 Vdout0_20ck47 = 1.8 time = 960
.meas tran vdout0_20ck47 FIND v(dout0_20) AT=960.1n

* CHECK dout0_21 Vdout0_21ck47 = 1.8 time = 960
.meas tran vdout0_21ck47 FIND v(dout0_21) AT=960.1n

* CHECK dout0_22 Vdout0_22ck47 = 1.8 time = 960
.meas tran vdout0_22ck47 FIND v(dout0_22) AT=960.1n

* CHECK dout0_23 Vdout0_23ck47 = 0 time = 960
.meas tran vdout0_23ck47 FIND v(dout0_23) AT=960.1n

* CHECK dout0_24 Vdout0_24ck47 = 1.8 time = 960
.meas tran vdout0_24ck47 FIND v(dout0_24) AT=960.1n

* CHECK dout0_25 Vdout0_25ck47 = 0 time = 960
.meas tran vdout0_25ck47 FIND v(dout0_25) AT=960.1n

* CHECK dout0_26 Vdout0_26ck47 = 0 time = 960
.meas tran vdout0_26ck47 FIND v(dout0_26) AT=960.1n

* CHECK dout0_27 Vdout0_27ck47 = 0 time = 960
.meas tran vdout0_27ck47 FIND v(dout0_27) AT=960.1n

* CHECK dout0_28 Vdout0_28ck47 = 1.8 time = 960
.meas tran vdout0_28ck47 FIND v(dout0_28) AT=960.1n

* CHECK dout0_29 Vdout0_29ck47 = 0 time = 960
.meas tran vdout0_29ck47 FIND v(dout0_29) AT=960.1n

* CHECK dout0_30 Vdout0_30ck47 = 1.8 time = 960
.meas tran vdout0_30ck47 FIND v(dout0_30) AT=960.1n

* CHECK dout0_31 Vdout0_31ck47 = 1.8 time = 960
.meas tran vdout0_31ck47 FIND v(dout0_31) AT=960.1n

* CHECK dout0_0 Vdout0_0ck48 = 1.8 time = 980
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=980.1n

* CHECK dout0_1 Vdout0_1ck48 = 0 time = 980
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=980.1n

* CHECK dout0_2 Vdout0_2ck48 = 1.8 time = 980
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=980.1n

* CHECK dout0_3 Vdout0_3ck48 = 0 time = 980
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=980.1n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 980
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=980.1n

* CHECK dout0_5 Vdout0_5ck48 = 1.8 time = 980
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=980.1n

* CHECK dout0_6 Vdout0_6ck48 = 1.8 time = 980
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=980.1n

* CHECK dout0_7 Vdout0_7ck48 = 0 time = 980
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=980.1n

* CHECK dout0_8 Vdout0_8ck48 = 0 time = 980
.meas tran vdout0_8ck48 FIND v(dout0_8) AT=980.1n

* CHECK dout0_9 Vdout0_9ck48 = 0 time = 980
.meas tran vdout0_9ck48 FIND v(dout0_9) AT=980.1n

* CHECK dout0_10 Vdout0_10ck48 = 1.8 time = 980
.meas tran vdout0_10ck48 FIND v(dout0_10) AT=980.1n

* CHECK dout0_11 Vdout0_11ck48 = 0 time = 980
.meas tran vdout0_11ck48 FIND v(dout0_11) AT=980.1n

* CHECK dout0_12 Vdout0_12ck48 = 0 time = 980
.meas tran vdout0_12ck48 FIND v(dout0_12) AT=980.1n

* CHECK dout0_13 Vdout0_13ck48 = 0 time = 980
.meas tran vdout0_13ck48 FIND v(dout0_13) AT=980.1n

* CHECK dout0_14 Vdout0_14ck48 = 0 time = 980
.meas tran vdout0_14ck48 FIND v(dout0_14) AT=980.1n

* CHECK dout0_15 Vdout0_15ck48 = 1.8 time = 980
.meas tran vdout0_15ck48 FIND v(dout0_15) AT=980.1n

* CHECK dout0_16 Vdout0_16ck48 = 1.8 time = 980
.meas tran vdout0_16ck48 FIND v(dout0_16) AT=980.1n

* CHECK dout0_17 Vdout0_17ck48 = 0 time = 980
.meas tran vdout0_17ck48 FIND v(dout0_17) AT=980.1n

* CHECK dout0_18 Vdout0_18ck48 = 1.8 time = 980
.meas tran vdout0_18ck48 FIND v(dout0_18) AT=980.1n

* CHECK dout0_19 Vdout0_19ck48 = 1.8 time = 980
.meas tran vdout0_19ck48 FIND v(dout0_19) AT=980.1n

* CHECK dout0_20 Vdout0_20ck48 = 1.8 time = 980
.meas tran vdout0_20ck48 FIND v(dout0_20) AT=980.1n

* CHECK dout0_21 Vdout0_21ck48 = 0 time = 980
.meas tran vdout0_21ck48 FIND v(dout0_21) AT=980.1n

* CHECK dout0_22 Vdout0_22ck48 = 1.8 time = 980
.meas tran vdout0_22ck48 FIND v(dout0_22) AT=980.1n

* CHECK dout0_23 Vdout0_23ck48 = 0 time = 980
.meas tran vdout0_23ck48 FIND v(dout0_23) AT=980.1n

* CHECK dout0_24 Vdout0_24ck48 = 1.8 time = 980
.meas tran vdout0_24ck48 FIND v(dout0_24) AT=980.1n

* CHECK dout0_25 Vdout0_25ck48 = 1.8 time = 980
.meas tran vdout0_25ck48 FIND v(dout0_25) AT=980.1n

* CHECK dout0_26 Vdout0_26ck48 = 1.8 time = 980
.meas tran vdout0_26ck48 FIND v(dout0_26) AT=980.1n

* CHECK dout0_27 Vdout0_27ck48 = 0 time = 980
.meas tran vdout0_27ck48 FIND v(dout0_27) AT=980.1n

* CHECK dout0_28 Vdout0_28ck48 = 1.8 time = 980
.meas tran vdout0_28ck48 FIND v(dout0_28) AT=980.1n

* CHECK dout0_29 Vdout0_29ck48 = 0 time = 980
.meas tran vdout0_29ck48 FIND v(dout0_29) AT=980.1n

* CHECK dout0_30 Vdout0_30ck48 = 0 time = 980
.meas tran vdout0_30ck48 FIND v(dout0_30) AT=980.1n

* CHECK dout0_31 Vdout0_31ck48 = 1.8 time = 980
.meas tran vdout0_31ck48 FIND v(dout0_31) AT=980.1n

* CHECK dout0_0 Vdout0_0ck50 = 1.8 time = 1020
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=1020.1n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 1020
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=1020.1n

* CHECK dout0_2 Vdout0_2ck50 = 1.8 time = 1020
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=1020.1n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 1020
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=1020.1n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 1020
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=1020.1n

* CHECK dout0_5 Vdout0_5ck50 = 1.8 time = 1020
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=1020.1n

* CHECK dout0_6 Vdout0_6ck50 = 1.8 time = 1020
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=1020.1n

* CHECK dout0_7 Vdout0_7ck50 = 0 time = 1020
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=1020.1n

* CHECK dout0_8 Vdout0_8ck50 = 0 time = 1020
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=1020.1n

* CHECK dout0_9 Vdout0_9ck50 = 0 time = 1020
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=1020.1n

* CHECK dout0_10 Vdout0_10ck50 = 1.8 time = 1020
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=1020.1n

* CHECK dout0_11 Vdout0_11ck50 = 0 time = 1020
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=1020.1n

* CHECK dout0_12 Vdout0_12ck50 = 0 time = 1020
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=1020.1n

* CHECK dout0_13 Vdout0_13ck50 = 0 time = 1020
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=1020.1n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 1020
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=1020.1n

* CHECK dout0_15 Vdout0_15ck50 = 1.8 time = 1020
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=1020.1n

* CHECK dout0_16 Vdout0_16ck50 = 1.8 time = 1020
.meas tran vdout0_16ck50 FIND v(dout0_16) AT=1020.1n

* CHECK dout0_17 Vdout0_17ck50 = 0 time = 1020
.meas tran vdout0_17ck50 FIND v(dout0_17) AT=1020.1n

* CHECK dout0_18 Vdout0_18ck50 = 1.8 time = 1020
.meas tran vdout0_18ck50 FIND v(dout0_18) AT=1020.1n

* CHECK dout0_19 Vdout0_19ck50 = 1.8 time = 1020
.meas tran vdout0_19ck50 FIND v(dout0_19) AT=1020.1n

* CHECK dout0_20 Vdout0_20ck50 = 1.8 time = 1020
.meas tran vdout0_20ck50 FIND v(dout0_20) AT=1020.1n

* CHECK dout0_21 Vdout0_21ck50 = 0 time = 1020
.meas tran vdout0_21ck50 FIND v(dout0_21) AT=1020.1n

* CHECK dout0_22 Vdout0_22ck50 = 1.8 time = 1020
.meas tran vdout0_22ck50 FIND v(dout0_22) AT=1020.1n

* CHECK dout0_23 Vdout0_23ck50 = 0 time = 1020
.meas tran vdout0_23ck50 FIND v(dout0_23) AT=1020.1n

* CHECK dout0_24 Vdout0_24ck50 = 1.8 time = 1020
.meas tran vdout0_24ck50 FIND v(dout0_24) AT=1020.1n

* CHECK dout0_25 Vdout0_25ck50 = 1.8 time = 1020
.meas tran vdout0_25ck50 FIND v(dout0_25) AT=1020.1n

* CHECK dout0_26 Vdout0_26ck50 = 1.8 time = 1020
.meas tran vdout0_26ck50 FIND v(dout0_26) AT=1020.1n

* CHECK dout0_27 Vdout0_27ck50 = 0 time = 1020
.meas tran vdout0_27ck50 FIND v(dout0_27) AT=1020.1n

* CHECK dout0_28 Vdout0_28ck50 = 1.8 time = 1020
.meas tran vdout0_28ck50 FIND v(dout0_28) AT=1020.1n

* CHECK dout0_29 Vdout0_29ck50 = 0 time = 1020
.meas tran vdout0_29ck50 FIND v(dout0_29) AT=1020.1n

* CHECK dout0_30 Vdout0_30ck50 = 0 time = 1020
.meas tran vdout0_30ck50 FIND v(dout0_30) AT=1020.1n

* CHECK dout0_31 Vdout0_31ck50 = 1.8 time = 1020
.meas tran vdout0_31ck50 FIND v(dout0_31) AT=1020.1n

* CHECK dout0_0 Vdout0_0ck51 = 0 time = 1040
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=1040.1n

* CHECK dout0_1 Vdout0_1ck51 = 0 time = 1040
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=1040.1n

* CHECK dout0_2 Vdout0_2ck51 = 0 time = 1040
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=1040.1n

* CHECK dout0_3 Vdout0_3ck51 = 0 time = 1040
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=1040.1n

* CHECK dout0_4 Vdout0_4ck51 = 1.8 time = 1040
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=1040.1n

* CHECK dout0_5 Vdout0_5ck51 = 0 time = 1040
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=1040.1n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 1040
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=1040.1n

* CHECK dout0_7 Vdout0_7ck51 = 0 time = 1040
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=1040.1n

* CHECK dout0_8 Vdout0_8ck51 = 1.8 time = 1040
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=1040.1n

* CHECK dout0_9 Vdout0_9ck51 = 0 time = 1040
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=1040.1n

* CHECK dout0_10 Vdout0_10ck51 = 0 time = 1040
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=1040.1n

* CHECK dout0_11 Vdout0_11ck51 = 1.8 time = 1040
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=1040.1n

* CHECK dout0_12 Vdout0_12ck51 = 0 time = 1040
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=1040.1n

* CHECK dout0_13 Vdout0_13ck51 = 0 time = 1040
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=1040.1n

* CHECK dout0_14 Vdout0_14ck51 = 1.8 time = 1040
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=1040.1n

* CHECK dout0_15 Vdout0_15ck51 = 1.8 time = 1040
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=1040.1n

* CHECK dout0_16 Vdout0_16ck51 = 1.8 time = 1040
.meas tran vdout0_16ck51 FIND v(dout0_16) AT=1040.1n

* CHECK dout0_17 Vdout0_17ck51 = 1.8 time = 1040
.meas tran vdout0_17ck51 FIND v(dout0_17) AT=1040.1n

* CHECK dout0_18 Vdout0_18ck51 = 1.8 time = 1040
.meas tran vdout0_18ck51 FIND v(dout0_18) AT=1040.1n

* CHECK dout0_19 Vdout0_19ck51 = 1.8 time = 1040
.meas tran vdout0_19ck51 FIND v(dout0_19) AT=1040.1n

* CHECK dout0_20 Vdout0_20ck51 = 0 time = 1040
.meas tran vdout0_20ck51 FIND v(dout0_20) AT=1040.1n

* CHECK dout0_21 Vdout0_21ck51 = 1.8 time = 1040
.meas tran vdout0_21ck51 FIND v(dout0_21) AT=1040.1n

* CHECK dout0_22 Vdout0_22ck51 = 1.8 time = 1040
.meas tran vdout0_22ck51 FIND v(dout0_22) AT=1040.1n

* CHECK dout0_23 Vdout0_23ck51 = 1.8 time = 1040
.meas tran vdout0_23ck51 FIND v(dout0_23) AT=1040.1n

* CHECK dout0_24 Vdout0_24ck51 = 1.8 time = 1040
.meas tran vdout0_24ck51 FIND v(dout0_24) AT=1040.1n

* CHECK dout0_25 Vdout0_25ck51 = 0 time = 1040
.meas tran vdout0_25ck51 FIND v(dout0_25) AT=1040.1n

* CHECK dout0_26 Vdout0_26ck51 = 1.8 time = 1040
.meas tran vdout0_26ck51 FIND v(dout0_26) AT=1040.1n

* CHECK dout0_27 Vdout0_27ck51 = 1.8 time = 1040
.meas tran vdout0_27ck51 FIND v(dout0_27) AT=1040.1n

* CHECK dout0_28 Vdout0_28ck51 = 0 time = 1040
.meas tran vdout0_28ck51 FIND v(dout0_28) AT=1040.1n

* CHECK dout0_29 Vdout0_29ck51 = 0 time = 1040
.meas tran vdout0_29ck51 FIND v(dout0_29) AT=1040.1n

* CHECK dout0_30 Vdout0_30ck51 = 0 time = 1040
.meas tran vdout0_30ck51 FIND v(dout0_30) AT=1040.1n

* CHECK dout0_31 Vdout0_31ck51 = 1.8 time = 1040
.meas tran vdout0_31ck51 FIND v(dout0_31) AT=1040.1n

* CHECK dout0_0 Vdout0_0ck53 = 1.8 time = 1080
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=1080.1n

* CHECK dout0_1 Vdout0_1ck53 = 1.8 time = 1080
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=1080.1n

* CHECK dout0_2 Vdout0_2ck53 = 1.8 time = 1080
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=1080.1n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 1080
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=1080.1n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 1080
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=1080.1n

* CHECK dout0_5 Vdout0_5ck53 = 1.8 time = 1080
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=1080.1n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 1080
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=1080.1n

* CHECK dout0_7 Vdout0_7ck53 = 0 time = 1080
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=1080.1n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 1080
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=1080.1n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 1080
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=1080.1n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 1080
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=1080.1n

* CHECK dout0_11 Vdout0_11ck53 = 0 time = 1080
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=1080.1n

* CHECK dout0_12 Vdout0_12ck53 = 1.8 time = 1080
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=1080.1n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 1080
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=1080.1n

* CHECK dout0_14 Vdout0_14ck53 = 1.8 time = 1080
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=1080.1n

* CHECK dout0_15 Vdout0_15ck53 = 0 time = 1080
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=1080.1n

* CHECK dout0_16 Vdout0_16ck53 = 1.8 time = 1080
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=1080.1n

* CHECK dout0_17 Vdout0_17ck53 = 0 time = 1080
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=1080.1n

* CHECK dout0_18 Vdout0_18ck53 = 1.8 time = 1080
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=1080.1n

* CHECK dout0_19 Vdout0_19ck53 = 1.8 time = 1080
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=1080.1n

* CHECK dout0_20 Vdout0_20ck53 = 1.8 time = 1080
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=1080.1n

* CHECK dout0_21 Vdout0_21ck53 = 1.8 time = 1080
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=1080.1n

* CHECK dout0_22 Vdout0_22ck53 = 0 time = 1080
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=1080.1n

* CHECK dout0_23 Vdout0_23ck53 = 0 time = 1080
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=1080.1n

* CHECK dout0_24 Vdout0_24ck53 = 1.8 time = 1080
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=1080.1n

* CHECK dout0_25 Vdout0_25ck53 = 0 time = 1080
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=1080.1n

* CHECK dout0_26 Vdout0_26ck53 = 0 time = 1080
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=1080.1n

* CHECK dout0_27 Vdout0_27ck53 = 1.8 time = 1080
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=1080.1n

* CHECK dout0_28 Vdout0_28ck53 = 1.8 time = 1080
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=1080.1n

* CHECK dout0_29 Vdout0_29ck53 = 0 time = 1080
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=1080.1n

* CHECK dout0_30 Vdout0_30ck53 = 1.8 time = 1080
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=1080.1n

* CHECK dout0_31 Vdout0_31ck53 = 1.8 time = 1080
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=1080.1n

* CHECK dout0_0 Vdout0_0ck55 = 1.8 time = 1120
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=1120.1n

* CHECK dout0_1 Vdout0_1ck55 = 1.8 time = 1120
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=1120.1n

* CHECK dout0_2 Vdout0_2ck55 = 1.8 time = 1120
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=1120.1n

* CHECK dout0_3 Vdout0_3ck55 = 1.8 time = 1120
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=1120.1n

* CHECK dout0_4 Vdout0_4ck55 = 0 time = 1120
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=1120.1n

* CHECK dout0_5 Vdout0_5ck55 = 0 time = 1120
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=1120.1n

* CHECK dout0_6 Vdout0_6ck55 = 1.8 time = 1120
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=1120.1n

* CHECK dout0_7 Vdout0_7ck55 = 0 time = 1120
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=1120.1n

* CHECK dout0_8 Vdout0_8ck55 = 0 time = 1120
.meas tran vdout0_8ck55 FIND v(dout0_8) AT=1120.1n

* CHECK dout0_9 Vdout0_9ck55 = 0 time = 1120
.meas tran vdout0_9ck55 FIND v(dout0_9) AT=1120.1n

* CHECK dout0_10 Vdout0_10ck55 = 0 time = 1120
.meas tran vdout0_10ck55 FIND v(dout0_10) AT=1120.1n

* CHECK dout0_11 Vdout0_11ck55 = 1.8 time = 1120
.meas tran vdout0_11ck55 FIND v(dout0_11) AT=1120.1n

* CHECK dout0_12 Vdout0_12ck55 = 1.8 time = 1120
.meas tran vdout0_12ck55 FIND v(dout0_12) AT=1120.1n

* CHECK dout0_13 Vdout0_13ck55 = 0 time = 1120
.meas tran vdout0_13ck55 FIND v(dout0_13) AT=1120.1n

* CHECK dout0_14 Vdout0_14ck55 = 1.8 time = 1120
.meas tran vdout0_14ck55 FIND v(dout0_14) AT=1120.1n

* CHECK dout0_15 Vdout0_15ck55 = 1.8 time = 1120
.meas tran vdout0_15ck55 FIND v(dout0_15) AT=1120.1n

* CHECK dout0_16 Vdout0_16ck55 = 1.8 time = 1120
.meas tran vdout0_16ck55 FIND v(dout0_16) AT=1120.1n

* CHECK dout0_17 Vdout0_17ck55 = 1.8 time = 1120
.meas tran vdout0_17ck55 FIND v(dout0_17) AT=1120.1n

* CHECK dout0_18 Vdout0_18ck55 = 1.8 time = 1120
.meas tran vdout0_18ck55 FIND v(dout0_18) AT=1120.1n

* CHECK dout0_19 Vdout0_19ck55 = 0 time = 1120
.meas tran vdout0_19ck55 FIND v(dout0_19) AT=1120.1n

* CHECK dout0_20 Vdout0_20ck55 = 1.8 time = 1120
.meas tran vdout0_20ck55 FIND v(dout0_20) AT=1120.1n

* CHECK dout0_21 Vdout0_21ck55 = 1.8 time = 1120
.meas tran vdout0_21ck55 FIND v(dout0_21) AT=1120.1n

* CHECK dout0_22 Vdout0_22ck55 = 1.8 time = 1120
.meas tran vdout0_22ck55 FIND v(dout0_22) AT=1120.1n

* CHECK dout0_23 Vdout0_23ck55 = 0 time = 1120
.meas tran vdout0_23ck55 FIND v(dout0_23) AT=1120.1n

* CHECK dout0_24 Vdout0_24ck55 = 1.8 time = 1120
.meas tran vdout0_24ck55 FIND v(dout0_24) AT=1120.1n

* CHECK dout0_25 Vdout0_25ck55 = 0 time = 1120
.meas tran vdout0_25ck55 FIND v(dout0_25) AT=1120.1n

* CHECK dout0_26 Vdout0_26ck55 = 0 time = 1120
.meas tran vdout0_26ck55 FIND v(dout0_26) AT=1120.1n

* CHECK dout0_27 Vdout0_27ck55 = 0 time = 1120
.meas tran vdout0_27ck55 FIND v(dout0_27) AT=1120.1n

* CHECK dout0_28 Vdout0_28ck55 = 1.8 time = 1120
.meas tran vdout0_28ck55 FIND v(dout0_28) AT=1120.1n

* CHECK dout0_29 Vdout0_29ck55 = 0 time = 1120
.meas tran vdout0_29ck55 FIND v(dout0_29) AT=1120.1n

* CHECK dout0_30 Vdout0_30ck55 = 1.8 time = 1120
.meas tran vdout0_30ck55 FIND v(dout0_30) AT=1120.1n

* CHECK dout0_31 Vdout0_31ck55 = 1.8 time = 1120
.meas tran vdout0_31ck55 FIND v(dout0_31) AT=1120.1n

* CHECK dout0_0 Vdout0_0ck61 = 0 time = 1240
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=1240.1n

* CHECK dout0_1 Vdout0_1ck61 = 1.8 time = 1240
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=1240.1n

* CHECK dout0_2 Vdout0_2ck61 = 1.8 time = 1240
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=1240.1n

* CHECK dout0_3 Vdout0_3ck61 = 1.8 time = 1240
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=1240.1n

* CHECK dout0_4 Vdout0_4ck61 = 0 time = 1240
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=1240.1n

* CHECK dout0_5 Vdout0_5ck61 = 1.8 time = 1240
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=1240.1n

* CHECK dout0_6 Vdout0_6ck61 = 0 time = 1240
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=1240.1n

* CHECK dout0_7 Vdout0_7ck61 = 1.8 time = 1240
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=1240.1n

* CHECK dout0_8 Vdout0_8ck61 = 0 time = 1240
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=1240.1n

* CHECK dout0_9 Vdout0_9ck61 = 1.8 time = 1240
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=1240.1n

* CHECK dout0_10 Vdout0_10ck61 = 1.8 time = 1240
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=1240.1n

* CHECK dout0_11 Vdout0_11ck61 = 1.8 time = 1240
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=1240.1n

* CHECK dout0_12 Vdout0_12ck61 = 0 time = 1240
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=1240.1n

* CHECK dout0_13 Vdout0_13ck61 = 0 time = 1240
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=1240.1n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 1240
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=1240.1n

* CHECK dout0_15 Vdout0_15ck61 = 0 time = 1240
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=1240.1n

* CHECK dout0_16 Vdout0_16ck61 = 0 time = 1240
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=1240.1n

* CHECK dout0_17 Vdout0_17ck61 = 0 time = 1240
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=1240.1n

* CHECK dout0_18 Vdout0_18ck61 = 0 time = 1240
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=1240.1n

* CHECK dout0_19 Vdout0_19ck61 = 0 time = 1240
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=1240.1n

* CHECK dout0_20 Vdout0_20ck61 = 1.8 time = 1240
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=1240.1n

* CHECK dout0_21 Vdout0_21ck61 = 1.8 time = 1240
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=1240.1n

* CHECK dout0_22 Vdout0_22ck61 = 0 time = 1240
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=1240.1n

* CHECK dout0_23 Vdout0_23ck61 = 1.8 time = 1240
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=1240.1n

* CHECK dout0_24 Vdout0_24ck61 = 1.8 time = 1240
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=1240.1n

* CHECK dout0_25 Vdout0_25ck61 = 0 time = 1240
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=1240.1n

* CHECK dout0_26 Vdout0_26ck61 = 0 time = 1240
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=1240.1n

* CHECK dout0_27 Vdout0_27ck61 = 0 time = 1240
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=1240.1n

* CHECK dout0_28 Vdout0_28ck61 = 1.8 time = 1240
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=1240.1n

* CHECK dout0_29 Vdout0_29ck61 = 0 time = 1240
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=1240.1n

* CHECK dout0_30 Vdout0_30ck61 = 0 time = 1240
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=1240.1n

* CHECK dout0_31 Vdout0_31ck61 = 1.8 time = 1240
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=1240.1n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 1260
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=1260.1n

* CHECK dout0_1 Vdout0_1ck62 = 0 time = 1260
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=1260.1n

* CHECK dout0_2 Vdout0_2ck62 = 0 time = 1260
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=1260.1n

* CHECK dout0_3 Vdout0_3ck62 = 0 time = 1260
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=1260.1n

* CHECK dout0_4 Vdout0_4ck62 = 0 time = 1260
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=1260.1n

* CHECK dout0_5 Vdout0_5ck62 = 0 time = 1260
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=1260.1n

* CHECK dout0_6 Vdout0_6ck62 = 0 time = 1260
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=1260.1n

* CHECK dout0_7 Vdout0_7ck62 = 1.8 time = 1260
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=1260.1n

* CHECK dout0_8 Vdout0_8ck62 = 1.8 time = 1260
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=1260.1n

* CHECK dout0_9 Vdout0_9ck62 = 0 time = 1260
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=1260.1n

* CHECK dout0_10 Vdout0_10ck62 = 0 time = 1260
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=1260.1n

* CHECK dout0_11 Vdout0_11ck62 = 1.8 time = 1260
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=1260.1n

* CHECK dout0_12 Vdout0_12ck62 = 0 time = 1260
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=1260.1n

* CHECK dout0_13 Vdout0_13ck62 = 1.8 time = 1260
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=1260.1n

* CHECK dout0_14 Vdout0_14ck62 = 1.8 time = 1260
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=1260.1n

* CHECK dout0_15 Vdout0_15ck62 = 0 time = 1260
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=1260.1n

* CHECK dout0_16 Vdout0_16ck62 = 1.8 time = 1260
.meas tran vdout0_16ck62 FIND v(dout0_16) AT=1260.1n

* CHECK dout0_17 Vdout0_17ck62 = 1.8 time = 1260
.meas tran vdout0_17ck62 FIND v(dout0_17) AT=1260.1n

* CHECK dout0_18 Vdout0_18ck62 = 1.8 time = 1260
.meas tran vdout0_18ck62 FIND v(dout0_18) AT=1260.1n

* CHECK dout0_19 Vdout0_19ck62 = 1.8 time = 1260
.meas tran vdout0_19ck62 FIND v(dout0_19) AT=1260.1n

* CHECK dout0_20 Vdout0_20ck62 = 0 time = 1260
.meas tran vdout0_20ck62 FIND v(dout0_20) AT=1260.1n

* CHECK dout0_21 Vdout0_21ck62 = 1.8 time = 1260
.meas tran vdout0_21ck62 FIND v(dout0_21) AT=1260.1n

* CHECK dout0_22 Vdout0_22ck62 = 0 time = 1260
.meas tran vdout0_22ck62 FIND v(dout0_22) AT=1260.1n

* CHECK dout0_23 Vdout0_23ck62 = 1.8 time = 1260
.meas tran vdout0_23ck62 FIND v(dout0_23) AT=1260.1n

* CHECK dout0_24 Vdout0_24ck62 = 1.8 time = 1260
.meas tran vdout0_24ck62 FIND v(dout0_24) AT=1260.1n

* CHECK dout0_25 Vdout0_25ck62 = 1.8 time = 1260
.meas tran vdout0_25ck62 FIND v(dout0_25) AT=1260.1n

* CHECK dout0_26 Vdout0_26ck62 = 1.8 time = 1260
.meas tran vdout0_26ck62 FIND v(dout0_26) AT=1260.1n

* CHECK dout0_27 Vdout0_27ck62 = 0 time = 1260
.meas tran vdout0_27ck62 FIND v(dout0_27) AT=1260.1n

* CHECK dout0_28 Vdout0_28ck62 = 1.8 time = 1260
.meas tran vdout0_28ck62 FIND v(dout0_28) AT=1260.1n

* CHECK dout0_29 Vdout0_29ck62 = 0 time = 1260
.meas tran vdout0_29ck62 FIND v(dout0_29) AT=1260.1n

* CHECK dout0_30 Vdout0_30ck62 = 0 time = 1260
.meas tran vdout0_30ck62 FIND v(dout0_30) AT=1260.1n

* CHECK dout0_31 Vdout0_31ck62 = 1.8 time = 1260
.meas tran vdout0_31ck62 FIND v(dout0_31) AT=1260.1n

* CHECK dout0_0 Vdout0_0ck64 = 1.8 time = 1300
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=1300.1n

* CHECK dout0_1 Vdout0_1ck64 = 1.8 time = 1300
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=1300.1n

* CHECK dout0_2 Vdout0_2ck64 = 1.8 time = 1300
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=1300.1n

* CHECK dout0_3 Vdout0_3ck64 = 0 time = 1300
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=1300.1n

* CHECK dout0_4 Vdout0_4ck64 = 0 time = 1300
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=1300.1n

* CHECK dout0_5 Vdout0_5ck64 = 0 time = 1300
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=1300.1n

* CHECK dout0_6 Vdout0_6ck64 = 0 time = 1300
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=1300.1n

* CHECK dout0_7 Vdout0_7ck64 = 0 time = 1300
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=1300.1n

* CHECK dout0_8 Vdout0_8ck64 = 0 time = 1300
.meas tran vdout0_8ck64 FIND v(dout0_8) AT=1300.1n

* CHECK dout0_9 Vdout0_9ck64 = 1.8 time = 1300
.meas tran vdout0_9ck64 FIND v(dout0_9) AT=1300.1n

* CHECK dout0_10 Vdout0_10ck64 = 0 time = 1300
.meas tran vdout0_10ck64 FIND v(dout0_10) AT=1300.1n

* CHECK dout0_11 Vdout0_11ck64 = 1.8 time = 1300
.meas tran vdout0_11ck64 FIND v(dout0_11) AT=1300.1n

* CHECK dout0_12 Vdout0_12ck64 = 1.8 time = 1300
.meas tran vdout0_12ck64 FIND v(dout0_12) AT=1300.1n

* CHECK dout0_13 Vdout0_13ck64 = 0 time = 1300
.meas tran vdout0_13ck64 FIND v(dout0_13) AT=1300.1n

* CHECK dout0_14 Vdout0_14ck64 = 0 time = 1300
.meas tran vdout0_14ck64 FIND v(dout0_14) AT=1300.1n

* CHECK dout0_15 Vdout0_15ck64 = 1.8 time = 1300
.meas tran vdout0_15ck64 FIND v(dout0_15) AT=1300.1n

* CHECK dout0_16 Vdout0_16ck64 = 1.8 time = 1300
.meas tran vdout0_16ck64 FIND v(dout0_16) AT=1300.1n

* CHECK dout0_17 Vdout0_17ck64 = 1.8 time = 1300
.meas tran vdout0_17ck64 FIND v(dout0_17) AT=1300.1n

* CHECK dout0_18 Vdout0_18ck64 = 0 time = 1300
.meas tran vdout0_18ck64 FIND v(dout0_18) AT=1300.1n

* CHECK dout0_19 Vdout0_19ck64 = 0 time = 1300
.meas tran vdout0_19ck64 FIND v(dout0_19) AT=1300.1n

* CHECK dout0_20 Vdout0_20ck64 = 0 time = 1300
.meas tran vdout0_20ck64 FIND v(dout0_20) AT=1300.1n

* CHECK dout0_21 Vdout0_21ck64 = 1.8 time = 1300
.meas tran vdout0_21ck64 FIND v(dout0_21) AT=1300.1n

* CHECK dout0_22 Vdout0_22ck64 = 0 time = 1300
.meas tran vdout0_22ck64 FIND v(dout0_22) AT=1300.1n

* CHECK dout0_23 Vdout0_23ck64 = 0 time = 1300
.meas tran vdout0_23ck64 FIND v(dout0_23) AT=1300.1n

* CHECK dout0_24 Vdout0_24ck64 = 0 time = 1300
.meas tran vdout0_24ck64 FIND v(dout0_24) AT=1300.1n

* CHECK dout0_25 Vdout0_25ck64 = 0 time = 1300
.meas tran vdout0_25ck64 FIND v(dout0_25) AT=1300.1n

* CHECK dout0_26 Vdout0_26ck64 = 0 time = 1300
.meas tran vdout0_26ck64 FIND v(dout0_26) AT=1300.1n

* CHECK dout0_27 Vdout0_27ck64 = 1.8 time = 1300
.meas tran vdout0_27ck64 FIND v(dout0_27) AT=1300.1n

* CHECK dout0_28 Vdout0_28ck64 = 0 time = 1300
.meas tran vdout0_28ck64 FIND v(dout0_28) AT=1300.1n

* CHECK dout0_29 Vdout0_29ck64 = 1.8 time = 1300
.meas tran vdout0_29ck64 FIND v(dout0_29) AT=1300.1n

* CHECK dout0_30 Vdout0_30ck64 = 0 time = 1300
.meas tran vdout0_30ck64 FIND v(dout0_30) AT=1300.1n

* CHECK dout0_31 Vdout0_31ck64 = 1.8 time = 1300
.meas tran vdout0_31ck64 FIND v(dout0_31) AT=1300.1n

* CHECK dout0_0 Vdout0_0ck65 = 0 time = 1320
.meas tran vdout0_0ck65 FIND v(dout0_0) AT=1320.1n

* CHECK dout0_1 Vdout0_1ck65 = 0 time = 1320
.meas tran vdout0_1ck65 FIND v(dout0_1) AT=1320.1n

* CHECK dout0_2 Vdout0_2ck65 = 1.8 time = 1320
.meas tran vdout0_2ck65 FIND v(dout0_2) AT=1320.1n

* CHECK dout0_3 Vdout0_3ck65 = 0 time = 1320
.meas tran vdout0_3ck65 FIND v(dout0_3) AT=1320.1n

* CHECK dout0_4 Vdout0_4ck65 = 1.8 time = 1320
.meas tran vdout0_4ck65 FIND v(dout0_4) AT=1320.1n

* CHECK dout0_5 Vdout0_5ck65 = 0 time = 1320
.meas tran vdout0_5ck65 FIND v(dout0_5) AT=1320.1n

* CHECK dout0_6 Vdout0_6ck65 = 0 time = 1320
.meas tran vdout0_6ck65 FIND v(dout0_6) AT=1320.1n

* CHECK dout0_7 Vdout0_7ck65 = 1.8 time = 1320
.meas tran vdout0_7ck65 FIND v(dout0_7) AT=1320.1n

* CHECK dout0_8 Vdout0_8ck65 = 1.8 time = 1320
.meas tran vdout0_8ck65 FIND v(dout0_8) AT=1320.1n

* CHECK dout0_9 Vdout0_9ck65 = 1.8 time = 1320
.meas tran vdout0_9ck65 FIND v(dout0_9) AT=1320.1n

* CHECK dout0_10 Vdout0_10ck65 = 1.8 time = 1320
.meas tran vdout0_10ck65 FIND v(dout0_10) AT=1320.1n

* CHECK dout0_11 Vdout0_11ck65 = 0 time = 1320
.meas tran vdout0_11ck65 FIND v(dout0_11) AT=1320.1n

* CHECK dout0_12 Vdout0_12ck65 = 1.8 time = 1320
.meas tran vdout0_12ck65 FIND v(dout0_12) AT=1320.1n

* CHECK dout0_13 Vdout0_13ck65 = 0 time = 1320
.meas tran vdout0_13ck65 FIND v(dout0_13) AT=1320.1n

* CHECK dout0_14 Vdout0_14ck65 = 1.8 time = 1320
.meas tran vdout0_14ck65 FIND v(dout0_14) AT=1320.1n

* CHECK dout0_15 Vdout0_15ck65 = 1.8 time = 1320
.meas tran vdout0_15ck65 FIND v(dout0_15) AT=1320.1n

* CHECK dout0_16 Vdout0_16ck65 = 1.8 time = 1320
.meas tran vdout0_16ck65 FIND v(dout0_16) AT=1320.1n

* CHECK dout0_17 Vdout0_17ck65 = 0 time = 1320
.meas tran vdout0_17ck65 FIND v(dout0_17) AT=1320.1n

* CHECK dout0_18 Vdout0_18ck65 = 1.8 time = 1320
.meas tran vdout0_18ck65 FIND v(dout0_18) AT=1320.1n

* CHECK dout0_19 Vdout0_19ck65 = 0 time = 1320
.meas tran vdout0_19ck65 FIND v(dout0_19) AT=1320.1n

* CHECK dout0_20 Vdout0_20ck65 = 1.8 time = 1320
.meas tran vdout0_20ck65 FIND v(dout0_20) AT=1320.1n

* CHECK dout0_21 Vdout0_21ck65 = 0 time = 1320
.meas tran vdout0_21ck65 FIND v(dout0_21) AT=1320.1n

* CHECK dout0_22 Vdout0_22ck65 = 1.8 time = 1320
.meas tran vdout0_22ck65 FIND v(dout0_22) AT=1320.1n

* CHECK dout0_23 Vdout0_23ck65 = 1.8 time = 1320
.meas tran vdout0_23ck65 FIND v(dout0_23) AT=1320.1n

* CHECK dout0_24 Vdout0_24ck65 = 0 time = 1320
.meas tran vdout0_24ck65 FIND v(dout0_24) AT=1320.1n

* CHECK dout0_25 Vdout0_25ck65 = 1.8 time = 1320
.meas tran vdout0_25ck65 FIND v(dout0_25) AT=1320.1n

* CHECK dout0_26 Vdout0_26ck65 = 1.8 time = 1320
.meas tran vdout0_26ck65 FIND v(dout0_26) AT=1320.1n

* CHECK dout0_27 Vdout0_27ck65 = 0 time = 1320
.meas tran vdout0_27ck65 FIND v(dout0_27) AT=1320.1n

* CHECK dout0_28 Vdout0_28ck65 = 1.8 time = 1320
.meas tran vdout0_28ck65 FIND v(dout0_28) AT=1320.1n

* CHECK dout0_29 Vdout0_29ck65 = 1.8 time = 1320
.meas tran vdout0_29ck65 FIND v(dout0_29) AT=1320.1n

* CHECK dout0_30 Vdout0_30ck65 = 1.8 time = 1320
.meas tran vdout0_30ck65 FIND v(dout0_30) AT=1320.1n

* CHECK dout0_31 Vdout0_31ck65 = 0 time = 1320
.meas tran vdout0_31ck65 FIND v(dout0_31) AT=1320.1n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 1340
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=1340.1n

* CHECK dout0_1 Vdout0_1ck66 = 0 time = 1340
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=1340.1n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 1340
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=1340.1n

* CHECK dout0_3 Vdout0_3ck66 = 0 time = 1340
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=1340.1n

* CHECK dout0_4 Vdout0_4ck66 = 1.8 time = 1340
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=1340.1n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 1340
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=1340.1n

* CHECK dout0_6 Vdout0_6ck66 = 0 time = 1340
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=1340.1n

* CHECK dout0_7 Vdout0_7ck66 = 0 time = 1340
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=1340.1n

* CHECK dout0_8 Vdout0_8ck66 = 1.8 time = 1340
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=1340.1n

* CHECK dout0_9 Vdout0_9ck66 = 0 time = 1340
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=1340.1n

* CHECK dout0_10 Vdout0_10ck66 = 0 time = 1340
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=1340.1n

* CHECK dout0_11 Vdout0_11ck66 = 1.8 time = 1340
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=1340.1n

* CHECK dout0_12 Vdout0_12ck66 = 0 time = 1340
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=1340.1n

* CHECK dout0_13 Vdout0_13ck66 = 0 time = 1340
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=1340.1n

* CHECK dout0_14 Vdout0_14ck66 = 1.8 time = 1340
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=1340.1n

* CHECK dout0_15 Vdout0_15ck66 = 1.8 time = 1340
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=1340.1n

* CHECK dout0_16 Vdout0_16ck66 = 1.8 time = 1340
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=1340.1n

* CHECK dout0_17 Vdout0_17ck66 = 1.8 time = 1340
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=1340.1n

* CHECK dout0_18 Vdout0_18ck66 = 1.8 time = 1340
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=1340.1n

* CHECK dout0_19 Vdout0_19ck66 = 1.8 time = 1340
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=1340.1n

* CHECK dout0_20 Vdout0_20ck66 = 0 time = 1340
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=1340.1n

* CHECK dout0_21 Vdout0_21ck66 = 1.8 time = 1340
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=1340.1n

* CHECK dout0_22 Vdout0_22ck66 = 1.8 time = 1340
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=1340.1n

* CHECK dout0_23 Vdout0_23ck66 = 1.8 time = 1340
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=1340.1n

* CHECK dout0_24 Vdout0_24ck66 = 1.8 time = 1340
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=1340.1n

* CHECK dout0_25 Vdout0_25ck66 = 0 time = 1340
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=1340.1n

* CHECK dout0_26 Vdout0_26ck66 = 1.8 time = 1340
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=1340.1n

* CHECK dout0_27 Vdout0_27ck66 = 1.8 time = 1340
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=1340.1n

* CHECK dout0_28 Vdout0_28ck66 = 0 time = 1340
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=1340.1n

* CHECK dout0_29 Vdout0_29ck66 = 0 time = 1340
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=1340.1n

* CHECK dout0_30 Vdout0_30ck66 = 0 time = 1340
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=1340.1n

* CHECK dout0_31 Vdout0_31ck66 = 1.8 time = 1340
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=1340.1n

* CHECK dout0_0 Vdout0_0ck72 = 1.8 time = 1460
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=1460.1n

* CHECK dout0_1 Vdout0_1ck72 = 0 time = 1460
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=1460.1n

* CHECK dout0_2 Vdout0_2ck72 = 1.8 time = 1460
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=1460.1n

* CHECK dout0_3 Vdout0_3ck72 = 1.8 time = 1460
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=1460.1n

* CHECK dout0_4 Vdout0_4ck72 = 1.8 time = 1460
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=1460.1n

* CHECK dout0_5 Vdout0_5ck72 = 1.8 time = 1460
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=1460.1n

* CHECK dout0_6 Vdout0_6ck72 = 1.8 time = 1460
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=1460.1n

* CHECK dout0_7 Vdout0_7ck72 = 0 time = 1460
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=1460.1n

* CHECK dout0_8 Vdout0_8ck72 = 1.8 time = 1460
.meas tran vdout0_8ck72 FIND v(dout0_8) AT=1460.1n

* CHECK dout0_9 Vdout0_9ck72 = 1.8 time = 1460
.meas tran vdout0_9ck72 FIND v(dout0_9) AT=1460.1n

* CHECK dout0_10 Vdout0_10ck72 = 1.8 time = 1460
.meas tran vdout0_10ck72 FIND v(dout0_10) AT=1460.1n

* CHECK dout0_11 Vdout0_11ck72 = 1.8 time = 1460
.meas tran vdout0_11ck72 FIND v(dout0_11) AT=1460.1n

* CHECK dout0_12 Vdout0_12ck72 = 0 time = 1460
.meas tran vdout0_12ck72 FIND v(dout0_12) AT=1460.1n

* CHECK dout0_13 Vdout0_13ck72 = 0 time = 1460
.meas tran vdout0_13ck72 FIND v(dout0_13) AT=1460.1n

* CHECK dout0_14 Vdout0_14ck72 = 1.8 time = 1460
.meas tran vdout0_14ck72 FIND v(dout0_14) AT=1460.1n

* CHECK dout0_15 Vdout0_15ck72 = 0 time = 1460
.meas tran vdout0_15ck72 FIND v(dout0_15) AT=1460.1n

* CHECK dout0_16 Vdout0_16ck72 = 0 time = 1460
.meas tran vdout0_16ck72 FIND v(dout0_16) AT=1460.1n

* CHECK dout0_17 Vdout0_17ck72 = 1.8 time = 1460
.meas tran vdout0_17ck72 FIND v(dout0_17) AT=1460.1n

* CHECK dout0_18 Vdout0_18ck72 = 1.8 time = 1460
.meas tran vdout0_18ck72 FIND v(dout0_18) AT=1460.1n

* CHECK dout0_19 Vdout0_19ck72 = 0 time = 1460
.meas tran vdout0_19ck72 FIND v(dout0_19) AT=1460.1n

* CHECK dout0_20 Vdout0_20ck72 = 1.8 time = 1460
.meas tran vdout0_20ck72 FIND v(dout0_20) AT=1460.1n

* CHECK dout0_21 Vdout0_21ck72 = 1.8 time = 1460
.meas tran vdout0_21ck72 FIND v(dout0_21) AT=1460.1n

* CHECK dout0_22 Vdout0_22ck72 = 1.8 time = 1460
.meas tran vdout0_22ck72 FIND v(dout0_22) AT=1460.1n

* CHECK dout0_23 Vdout0_23ck72 = 0 time = 1460
.meas tran vdout0_23ck72 FIND v(dout0_23) AT=1460.1n

* CHECK dout0_24 Vdout0_24ck72 = 1.8 time = 1460
.meas tran vdout0_24ck72 FIND v(dout0_24) AT=1460.1n

* CHECK dout0_25 Vdout0_25ck72 = 1.8 time = 1460
.meas tran vdout0_25ck72 FIND v(dout0_25) AT=1460.1n

* CHECK dout0_26 Vdout0_26ck72 = 1.8 time = 1460
.meas tran vdout0_26ck72 FIND v(dout0_26) AT=1460.1n

* CHECK dout0_27 Vdout0_27ck72 = 0 time = 1460
.meas tran vdout0_27ck72 FIND v(dout0_27) AT=1460.1n

* CHECK dout0_28 Vdout0_28ck72 = 0 time = 1460
.meas tran vdout0_28ck72 FIND v(dout0_28) AT=1460.1n

* CHECK dout0_29 Vdout0_29ck72 = 1.8 time = 1460
.meas tran vdout0_29ck72 FIND v(dout0_29) AT=1460.1n

* CHECK dout0_30 Vdout0_30ck72 = 1.8 time = 1460
.meas tran vdout0_30ck72 FIND v(dout0_30) AT=1460.1n

* CHECK dout0_31 Vdout0_31ck72 = 1.8 time = 1460
.meas tran vdout0_31ck72 FIND v(dout0_31) AT=1460.1n

* CHECK dout0_0 Vdout0_0ck74 = 0 time = 1500
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=1500.1n

* CHECK dout0_1 Vdout0_1ck74 = 1.8 time = 1500
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=1500.1n

* CHECK dout0_2 Vdout0_2ck74 = 1.8 time = 1500
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=1500.1n

* CHECK dout0_3 Vdout0_3ck74 = 1.8 time = 1500
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=1500.1n

* CHECK dout0_4 Vdout0_4ck74 = 0 time = 1500
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=1500.1n

* CHECK dout0_5 Vdout0_5ck74 = 1.8 time = 1500
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=1500.1n

* CHECK dout0_6 Vdout0_6ck74 = 0 time = 1500
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=1500.1n

* CHECK dout0_7 Vdout0_7ck74 = 1.8 time = 1500
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=1500.1n

* CHECK dout0_8 Vdout0_8ck74 = 0 time = 1500
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=1500.1n

* CHECK dout0_9 Vdout0_9ck74 = 1.8 time = 1500
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=1500.1n

* CHECK dout0_10 Vdout0_10ck74 = 1.8 time = 1500
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=1500.1n

* CHECK dout0_11 Vdout0_11ck74 = 1.8 time = 1500
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=1500.1n

* CHECK dout0_12 Vdout0_12ck74 = 0 time = 1500
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=1500.1n

* CHECK dout0_13 Vdout0_13ck74 = 0 time = 1500
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=1500.1n

* CHECK dout0_14 Vdout0_14ck74 = 0 time = 1500
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=1500.1n

* CHECK dout0_15 Vdout0_15ck74 = 0 time = 1500
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=1500.1n

* CHECK dout0_16 Vdout0_16ck74 = 0 time = 1500
.meas tran vdout0_16ck74 FIND v(dout0_16) AT=1500.1n

* CHECK dout0_17 Vdout0_17ck74 = 0 time = 1500
.meas tran vdout0_17ck74 FIND v(dout0_17) AT=1500.1n

* CHECK dout0_18 Vdout0_18ck74 = 0 time = 1500
.meas tran vdout0_18ck74 FIND v(dout0_18) AT=1500.1n

* CHECK dout0_19 Vdout0_19ck74 = 0 time = 1500
.meas tran vdout0_19ck74 FIND v(dout0_19) AT=1500.1n

* CHECK dout0_20 Vdout0_20ck74 = 1.8 time = 1500
.meas tran vdout0_20ck74 FIND v(dout0_20) AT=1500.1n

* CHECK dout0_21 Vdout0_21ck74 = 1.8 time = 1500
.meas tran vdout0_21ck74 FIND v(dout0_21) AT=1500.1n

* CHECK dout0_22 Vdout0_22ck74 = 0 time = 1500
.meas tran vdout0_22ck74 FIND v(dout0_22) AT=1500.1n

* CHECK dout0_23 Vdout0_23ck74 = 1.8 time = 1500
.meas tran vdout0_23ck74 FIND v(dout0_23) AT=1500.1n

* CHECK dout0_24 Vdout0_24ck74 = 1.8 time = 1500
.meas tran vdout0_24ck74 FIND v(dout0_24) AT=1500.1n

* CHECK dout0_25 Vdout0_25ck74 = 0 time = 1500
.meas tran vdout0_25ck74 FIND v(dout0_25) AT=1500.1n

* CHECK dout0_26 Vdout0_26ck74 = 0 time = 1500
.meas tran vdout0_26ck74 FIND v(dout0_26) AT=1500.1n

* CHECK dout0_27 Vdout0_27ck74 = 0 time = 1500
.meas tran vdout0_27ck74 FIND v(dout0_27) AT=1500.1n

* CHECK dout0_28 Vdout0_28ck74 = 1.8 time = 1500
.meas tran vdout0_28ck74 FIND v(dout0_28) AT=1500.1n

* CHECK dout0_29 Vdout0_29ck74 = 0 time = 1500
.meas tran vdout0_29ck74 FIND v(dout0_29) AT=1500.1n

* CHECK dout0_30 Vdout0_30ck74 = 0 time = 1500
.meas tran vdout0_30ck74 FIND v(dout0_30) AT=1500.1n

* CHECK dout0_31 Vdout0_31ck74 = 1.8 time = 1500
.meas tran vdout0_31ck74 FIND v(dout0_31) AT=1500.1n

* CHECK dout0_0 Vdout0_0ck76 = 1.8 time = 1540
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=1540.1n

* CHECK dout0_1 Vdout0_1ck76 = 0 time = 1540
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=1540.1n

* CHECK dout0_2 Vdout0_2ck76 = 0 time = 1540
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=1540.1n

* CHECK dout0_3 Vdout0_3ck76 = 1.8 time = 1540
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=1540.1n

* CHECK dout0_4 Vdout0_4ck76 = 0 time = 1540
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=1540.1n

* CHECK dout0_5 Vdout0_5ck76 = 0 time = 1540
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=1540.1n

* CHECK dout0_6 Vdout0_6ck76 = 0 time = 1540
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=1540.1n

* CHECK dout0_7 Vdout0_7ck76 = 1.8 time = 1540
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=1540.1n

* CHECK dout0_8 Vdout0_8ck76 = 1.8 time = 1540
.meas tran vdout0_8ck76 FIND v(dout0_8) AT=1540.1n

* CHECK dout0_9 Vdout0_9ck76 = 1.8 time = 1540
.meas tran vdout0_9ck76 FIND v(dout0_9) AT=1540.1n

* CHECK dout0_10 Vdout0_10ck76 = 0 time = 1540
.meas tran vdout0_10ck76 FIND v(dout0_10) AT=1540.1n

* CHECK dout0_11 Vdout0_11ck76 = 0 time = 1540
.meas tran vdout0_11ck76 FIND v(dout0_11) AT=1540.1n

* CHECK dout0_12 Vdout0_12ck76 = 1.8 time = 1540
.meas tran vdout0_12ck76 FIND v(dout0_12) AT=1540.1n

* CHECK dout0_13 Vdout0_13ck76 = 1.8 time = 1540
.meas tran vdout0_13ck76 FIND v(dout0_13) AT=1540.1n

* CHECK dout0_14 Vdout0_14ck76 = 1.8 time = 1540
.meas tran vdout0_14ck76 FIND v(dout0_14) AT=1540.1n

* CHECK dout0_15 Vdout0_15ck76 = 1.8 time = 1540
.meas tran vdout0_15ck76 FIND v(dout0_15) AT=1540.1n

* CHECK dout0_16 Vdout0_16ck76 = 1.8 time = 1540
.meas tran vdout0_16ck76 FIND v(dout0_16) AT=1540.1n

* CHECK dout0_17 Vdout0_17ck76 = 0 time = 1540
.meas tran vdout0_17ck76 FIND v(dout0_17) AT=1540.1n

* CHECK dout0_18 Vdout0_18ck76 = 0 time = 1540
.meas tran vdout0_18ck76 FIND v(dout0_18) AT=1540.1n

* CHECK dout0_19 Vdout0_19ck76 = 0 time = 1540
.meas tran vdout0_19ck76 FIND v(dout0_19) AT=1540.1n

* CHECK dout0_20 Vdout0_20ck76 = 0 time = 1540
.meas tran vdout0_20ck76 FIND v(dout0_20) AT=1540.1n

* CHECK dout0_21 Vdout0_21ck76 = 0 time = 1540
.meas tran vdout0_21ck76 FIND v(dout0_21) AT=1540.1n

* CHECK dout0_22 Vdout0_22ck76 = 1.8 time = 1540
.meas tran vdout0_22ck76 FIND v(dout0_22) AT=1540.1n

* CHECK dout0_23 Vdout0_23ck76 = 1.8 time = 1540
.meas tran vdout0_23ck76 FIND v(dout0_23) AT=1540.1n

* CHECK dout0_24 Vdout0_24ck76 = 1.8 time = 1540
.meas tran vdout0_24ck76 FIND v(dout0_24) AT=1540.1n

* CHECK dout0_25 Vdout0_25ck76 = 1.8 time = 1540
.meas tran vdout0_25ck76 FIND v(dout0_25) AT=1540.1n

* CHECK dout0_26 Vdout0_26ck76 = 0 time = 1540
.meas tran vdout0_26ck76 FIND v(dout0_26) AT=1540.1n

* CHECK dout0_27 Vdout0_27ck76 = 0 time = 1540
.meas tran vdout0_27ck76 FIND v(dout0_27) AT=1540.1n

* CHECK dout0_28 Vdout0_28ck76 = 0 time = 1540
.meas tran vdout0_28ck76 FIND v(dout0_28) AT=1540.1n

* CHECK dout0_29 Vdout0_29ck76 = 1.8 time = 1540
.meas tran vdout0_29ck76 FIND v(dout0_29) AT=1540.1n

* CHECK dout0_30 Vdout0_30ck76 = 0 time = 1540
.meas tran vdout0_30ck76 FIND v(dout0_30) AT=1540.1n

* CHECK dout0_31 Vdout0_31ck76 = 0 time = 1540
.meas tran vdout0_31ck76 FIND v(dout0_31) AT=1540.1n

* CHECK dout0_0 Vdout0_0ck77 = 1.8 time = 1560
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=1560.1n

* CHECK dout0_1 Vdout0_1ck77 = 1.8 time = 1560
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=1560.1n

* CHECK dout0_2 Vdout0_2ck77 = 1.8 time = 1560
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=1560.1n

* CHECK dout0_3 Vdout0_3ck77 = 1.8 time = 1560
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=1560.1n

* CHECK dout0_4 Vdout0_4ck77 = 0 time = 1560
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=1560.1n

* CHECK dout0_5 Vdout0_5ck77 = 0 time = 1560
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=1560.1n

* CHECK dout0_6 Vdout0_6ck77 = 1.8 time = 1560
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=1560.1n

* CHECK dout0_7 Vdout0_7ck77 = 0 time = 1560
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=1560.1n

* CHECK dout0_8 Vdout0_8ck77 = 0 time = 1560
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=1560.1n

* CHECK dout0_9 Vdout0_9ck77 = 0 time = 1560
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=1560.1n

* CHECK dout0_10 Vdout0_10ck77 = 0 time = 1560
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=1560.1n

* CHECK dout0_11 Vdout0_11ck77 = 1.8 time = 1560
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=1560.1n

* CHECK dout0_12 Vdout0_12ck77 = 1.8 time = 1560
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=1560.1n

* CHECK dout0_13 Vdout0_13ck77 = 0 time = 1560
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=1560.1n

* CHECK dout0_14 Vdout0_14ck77 = 1.8 time = 1560
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=1560.1n

* CHECK dout0_15 Vdout0_15ck77 = 1.8 time = 1560
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=1560.1n

* CHECK dout0_16 Vdout0_16ck77 = 1.8 time = 1560
.meas tran vdout0_16ck77 FIND v(dout0_16) AT=1560.1n

* CHECK dout0_17 Vdout0_17ck77 = 1.8 time = 1560
.meas tran vdout0_17ck77 FIND v(dout0_17) AT=1560.1n

* CHECK dout0_18 Vdout0_18ck77 = 1.8 time = 1560
.meas tran vdout0_18ck77 FIND v(dout0_18) AT=1560.1n

* CHECK dout0_19 Vdout0_19ck77 = 0 time = 1560
.meas tran vdout0_19ck77 FIND v(dout0_19) AT=1560.1n

* CHECK dout0_20 Vdout0_20ck77 = 1.8 time = 1560
.meas tran vdout0_20ck77 FIND v(dout0_20) AT=1560.1n

* CHECK dout0_21 Vdout0_21ck77 = 1.8 time = 1560
.meas tran vdout0_21ck77 FIND v(dout0_21) AT=1560.1n

* CHECK dout0_22 Vdout0_22ck77 = 1.8 time = 1560
.meas tran vdout0_22ck77 FIND v(dout0_22) AT=1560.1n

* CHECK dout0_23 Vdout0_23ck77 = 0 time = 1560
.meas tran vdout0_23ck77 FIND v(dout0_23) AT=1560.1n

* CHECK dout0_24 Vdout0_24ck77 = 1.8 time = 1560
.meas tran vdout0_24ck77 FIND v(dout0_24) AT=1560.1n

* CHECK dout0_25 Vdout0_25ck77 = 0 time = 1560
.meas tran vdout0_25ck77 FIND v(dout0_25) AT=1560.1n

* CHECK dout0_26 Vdout0_26ck77 = 0 time = 1560
.meas tran vdout0_26ck77 FIND v(dout0_26) AT=1560.1n

* CHECK dout0_27 Vdout0_27ck77 = 0 time = 1560
.meas tran vdout0_27ck77 FIND v(dout0_27) AT=1560.1n

* CHECK dout0_28 Vdout0_28ck77 = 1.8 time = 1560
.meas tran vdout0_28ck77 FIND v(dout0_28) AT=1560.1n

* CHECK dout0_29 Vdout0_29ck77 = 0 time = 1560
.meas tran vdout0_29ck77 FIND v(dout0_29) AT=1560.1n

* CHECK dout0_30 Vdout0_30ck77 = 1.8 time = 1560
.meas tran vdout0_30ck77 FIND v(dout0_30) AT=1560.1n

* CHECK dout0_31 Vdout0_31ck77 = 1.8 time = 1560
.meas tran vdout0_31ck77 FIND v(dout0_31) AT=1560.1n

* CHECK dout0_0 Vdout0_0ck79 = 1.8 time = 1600
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=1600.1n

* CHECK dout0_1 Vdout0_1ck79 = 1.8 time = 1600
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=1600.1n

* CHECK dout0_2 Vdout0_2ck79 = 1.8 time = 1600
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=1600.1n

* CHECK dout0_3 Vdout0_3ck79 = 1.8 time = 1600
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=1600.1n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 1600
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=1600.1n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 1600
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=1600.1n

* CHECK dout0_6 Vdout0_6ck79 = 1.8 time = 1600
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=1600.1n

* CHECK dout0_7 Vdout0_7ck79 = 0 time = 1600
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=1600.1n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 1600
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=1600.1n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 1600
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=1600.1n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 1600
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=1600.1n

* CHECK dout0_11 Vdout0_11ck79 = 1.8 time = 1600
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=1600.1n

* CHECK dout0_12 Vdout0_12ck79 = 1.8 time = 1600
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=1600.1n

* CHECK dout0_13 Vdout0_13ck79 = 0 time = 1600
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=1600.1n

* CHECK dout0_14 Vdout0_14ck79 = 1.8 time = 1600
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=1600.1n

* CHECK dout0_15 Vdout0_15ck79 = 1.8 time = 1600
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=1600.1n

* CHECK dout0_16 Vdout0_16ck79 = 1.8 time = 1600
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=1600.1n

* CHECK dout0_17 Vdout0_17ck79 = 1.8 time = 1600
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=1600.1n

* CHECK dout0_18 Vdout0_18ck79 = 1.8 time = 1600
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=1600.1n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 1600
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=1600.1n

* CHECK dout0_20 Vdout0_20ck79 = 1.8 time = 1600
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=1600.1n

* CHECK dout0_21 Vdout0_21ck79 = 1.8 time = 1600
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=1600.1n

* CHECK dout0_22 Vdout0_22ck79 = 1.8 time = 1600
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=1600.1n

* CHECK dout0_23 Vdout0_23ck79 = 0 time = 1600
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=1600.1n

* CHECK dout0_24 Vdout0_24ck79 = 1.8 time = 1600
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=1600.1n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 1600
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=1600.1n

* CHECK dout0_26 Vdout0_26ck79 = 0 time = 1600
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=1600.1n

* CHECK dout0_27 Vdout0_27ck79 = 0 time = 1600
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=1600.1n

* CHECK dout0_28 Vdout0_28ck79 = 1.8 time = 1600
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=1600.1n

* CHECK dout0_29 Vdout0_29ck79 = 0 time = 1600
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=1600.1n

* CHECK dout0_30 Vdout0_30ck79 = 1.8 time = 1600
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=1600.1n

* CHECK dout0_31 Vdout0_31ck79 = 1.8 time = 1600
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=1600.1n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 1620
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=1620.1n

* CHECK dout0_1 Vdout0_1ck80 = 1.8 time = 1620
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=1620.1n

* CHECK dout0_2 Vdout0_2ck80 = 0 time = 1620
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=1620.1n

* CHECK dout0_3 Vdout0_3ck80 = 1.8 time = 1620
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=1620.1n

* CHECK dout0_4 Vdout0_4ck80 = 1.8 time = 1620
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=1620.1n

* CHECK dout0_5 Vdout0_5ck80 = 0 time = 1620
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=1620.1n

* CHECK dout0_6 Vdout0_6ck80 = 0 time = 1620
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=1620.1n

* CHECK dout0_7 Vdout0_7ck80 = 0 time = 1620
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=1620.1n

* CHECK dout0_8 Vdout0_8ck80 = 0 time = 1620
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=1620.1n

* CHECK dout0_9 Vdout0_9ck80 = 1.8 time = 1620
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=1620.1n

* CHECK dout0_10 Vdout0_10ck80 = 1.8 time = 1620
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=1620.1n

* CHECK dout0_11 Vdout0_11ck80 = 1.8 time = 1620
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=1620.1n

* CHECK dout0_12 Vdout0_12ck80 = 1.8 time = 1620
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=1620.1n

* CHECK dout0_13 Vdout0_13ck80 = 1.8 time = 1620
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=1620.1n

* CHECK dout0_14 Vdout0_14ck80 = 1.8 time = 1620
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=1620.1n

* CHECK dout0_15 Vdout0_15ck80 = 1.8 time = 1620
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=1620.1n

* CHECK dout0_16 Vdout0_16ck80 = 1.8 time = 1620
.meas tran vdout0_16ck80 FIND v(dout0_16) AT=1620.1n

* CHECK dout0_17 Vdout0_17ck80 = 1.8 time = 1620
.meas tran vdout0_17ck80 FIND v(dout0_17) AT=1620.1n

* CHECK dout0_18 Vdout0_18ck80 = 0 time = 1620
.meas tran vdout0_18ck80 FIND v(dout0_18) AT=1620.1n

* CHECK dout0_19 Vdout0_19ck80 = 1.8 time = 1620
.meas tran vdout0_19ck80 FIND v(dout0_19) AT=1620.1n

* CHECK dout0_20 Vdout0_20ck80 = 1.8 time = 1620
.meas tran vdout0_20ck80 FIND v(dout0_20) AT=1620.1n

* CHECK dout0_21 Vdout0_21ck80 = 1.8 time = 1620
.meas tran vdout0_21ck80 FIND v(dout0_21) AT=1620.1n

* CHECK dout0_22 Vdout0_22ck80 = 0 time = 1620
.meas tran vdout0_22ck80 FIND v(dout0_22) AT=1620.1n

* CHECK dout0_23 Vdout0_23ck80 = 0 time = 1620
.meas tran vdout0_23ck80 FIND v(dout0_23) AT=1620.1n

* CHECK dout0_24 Vdout0_24ck80 = 1.8 time = 1620
.meas tran vdout0_24ck80 FIND v(dout0_24) AT=1620.1n

* CHECK dout0_25 Vdout0_25ck80 = 0 time = 1620
.meas tran vdout0_25ck80 FIND v(dout0_25) AT=1620.1n

* CHECK dout0_26 Vdout0_26ck80 = 1.8 time = 1620
.meas tran vdout0_26ck80 FIND v(dout0_26) AT=1620.1n

* CHECK dout0_27 Vdout0_27ck80 = 0 time = 1620
.meas tran vdout0_27ck80 FIND v(dout0_27) AT=1620.1n

* CHECK dout0_28 Vdout0_28ck80 = 0 time = 1620
.meas tran vdout0_28ck80 FIND v(dout0_28) AT=1620.1n

* CHECK dout0_29 Vdout0_29ck80 = 0 time = 1620
.meas tran vdout0_29ck80 FIND v(dout0_29) AT=1620.1n

* CHECK dout0_30 Vdout0_30ck80 = 1.8 time = 1620
.meas tran vdout0_30ck80 FIND v(dout0_30) AT=1620.1n

* CHECK dout0_31 Vdout0_31ck80 = 0 time = 1620
.meas tran vdout0_31ck80 FIND v(dout0_31) AT=1620.1n

* CHECK dout0_0 Vdout0_0ck81 = 1.8 time = 1640
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=1640.1n

* CHECK dout0_1 Vdout0_1ck81 = 1.8 time = 1640
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=1640.1n

* CHECK dout0_2 Vdout0_2ck81 = 1.8 time = 1640
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=1640.1n

* CHECK dout0_3 Vdout0_3ck81 = 1.8 time = 1640
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=1640.1n

* CHECK dout0_4 Vdout0_4ck81 = 0 time = 1640
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=1640.1n

* CHECK dout0_5 Vdout0_5ck81 = 0 time = 1640
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=1640.1n

* CHECK dout0_6 Vdout0_6ck81 = 1.8 time = 1640
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=1640.1n

* CHECK dout0_7 Vdout0_7ck81 = 0 time = 1640
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=1640.1n

* CHECK dout0_8 Vdout0_8ck81 = 0 time = 1640
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=1640.1n

* CHECK dout0_9 Vdout0_9ck81 = 0 time = 1640
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=1640.1n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 1640
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=1640.1n

* CHECK dout0_11 Vdout0_11ck81 = 1.8 time = 1640
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=1640.1n

* CHECK dout0_12 Vdout0_12ck81 = 1.8 time = 1640
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=1640.1n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 1640
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=1640.1n

* CHECK dout0_14 Vdout0_14ck81 = 1.8 time = 1640
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=1640.1n

* CHECK dout0_15 Vdout0_15ck81 = 1.8 time = 1640
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=1640.1n

* CHECK dout0_16 Vdout0_16ck81 = 1.8 time = 1640
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=1640.1n

* CHECK dout0_17 Vdout0_17ck81 = 1.8 time = 1640
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=1640.1n

* CHECK dout0_18 Vdout0_18ck81 = 1.8 time = 1640
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=1640.1n

* CHECK dout0_19 Vdout0_19ck81 = 0 time = 1640
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=1640.1n

* CHECK dout0_20 Vdout0_20ck81 = 1.8 time = 1640
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=1640.1n

* CHECK dout0_21 Vdout0_21ck81 = 1.8 time = 1640
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=1640.1n

* CHECK dout0_22 Vdout0_22ck81 = 1.8 time = 1640
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=1640.1n

* CHECK dout0_23 Vdout0_23ck81 = 0 time = 1640
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=1640.1n

* CHECK dout0_24 Vdout0_24ck81 = 1.8 time = 1640
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=1640.1n

* CHECK dout0_25 Vdout0_25ck81 = 0 time = 1640
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=1640.1n

* CHECK dout0_26 Vdout0_26ck81 = 0 time = 1640
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=1640.1n

* CHECK dout0_27 Vdout0_27ck81 = 0 time = 1640
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=1640.1n

* CHECK dout0_28 Vdout0_28ck81 = 1.8 time = 1640
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=1640.1n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 1640
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=1640.1n

* CHECK dout0_30 Vdout0_30ck81 = 1.8 time = 1640
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=1640.1n

* CHECK dout0_31 Vdout0_31ck81 = 1.8 time = 1640
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=1640.1n

* CHECK dout0_0 Vdout0_0ck82 = 0 time = 1660
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=1660.1n

* CHECK dout0_1 Vdout0_1ck82 = 0 time = 1660
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=1660.1n

* CHECK dout0_2 Vdout0_2ck82 = 1.8 time = 1660
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=1660.1n

* CHECK dout0_3 Vdout0_3ck82 = 0 time = 1660
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=1660.1n

* CHECK dout0_4 Vdout0_4ck82 = 1.8 time = 1660
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=1660.1n

* CHECK dout0_5 Vdout0_5ck82 = 0 time = 1660
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=1660.1n

* CHECK dout0_6 Vdout0_6ck82 = 0 time = 1660
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=1660.1n

* CHECK dout0_7 Vdout0_7ck82 = 1.8 time = 1660
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=1660.1n

* CHECK dout0_8 Vdout0_8ck82 = 1.8 time = 1660
.meas tran vdout0_8ck82 FIND v(dout0_8) AT=1660.1n

* CHECK dout0_9 Vdout0_9ck82 = 1.8 time = 1660
.meas tran vdout0_9ck82 FIND v(dout0_9) AT=1660.1n

* CHECK dout0_10 Vdout0_10ck82 = 1.8 time = 1660
.meas tran vdout0_10ck82 FIND v(dout0_10) AT=1660.1n

* CHECK dout0_11 Vdout0_11ck82 = 0 time = 1660
.meas tran vdout0_11ck82 FIND v(dout0_11) AT=1660.1n

* CHECK dout0_12 Vdout0_12ck82 = 1.8 time = 1660
.meas tran vdout0_12ck82 FIND v(dout0_12) AT=1660.1n

* CHECK dout0_13 Vdout0_13ck82 = 0 time = 1660
.meas tran vdout0_13ck82 FIND v(dout0_13) AT=1660.1n

* CHECK dout0_14 Vdout0_14ck82 = 1.8 time = 1660
.meas tran vdout0_14ck82 FIND v(dout0_14) AT=1660.1n

* CHECK dout0_15 Vdout0_15ck82 = 1.8 time = 1660
.meas tran vdout0_15ck82 FIND v(dout0_15) AT=1660.1n

* CHECK dout0_16 Vdout0_16ck82 = 1.8 time = 1660
.meas tran vdout0_16ck82 FIND v(dout0_16) AT=1660.1n

* CHECK dout0_17 Vdout0_17ck82 = 0 time = 1660
.meas tran vdout0_17ck82 FIND v(dout0_17) AT=1660.1n

* CHECK dout0_18 Vdout0_18ck82 = 1.8 time = 1660
.meas tran vdout0_18ck82 FIND v(dout0_18) AT=1660.1n

* CHECK dout0_19 Vdout0_19ck82 = 0 time = 1660
.meas tran vdout0_19ck82 FIND v(dout0_19) AT=1660.1n

* CHECK dout0_20 Vdout0_20ck82 = 1.8 time = 1660
.meas tran vdout0_20ck82 FIND v(dout0_20) AT=1660.1n

* CHECK dout0_21 Vdout0_21ck82 = 0 time = 1660
.meas tran vdout0_21ck82 FIND v(dout0_21) AT=1660.1n

* CHECK dout0_22 Vdout0_22ck82 = 1.8 time = 1660
.meas tran vdout0_22ck82 FIND v(dout0_22) AT=1660.1n

* CHECK dout0_23 Vdout0_23ck82 = 1.8 time = 1660
.meas tran vdout0_23ck82 FIND v(dout0_23) AT=1660.1n

* CHECK dout0_24 Vdout0_24ck82 = 0 time = 1660
.meas tran vdout0_24ck82 FIND v(dout0_24) AT=1660.1n

* CHECK dout0_25 Vdout0_25ck82 = 1.8 time = 1660
.meas tran vdout0_25ck82 FIND v(dout0_25) AT=1660.1n

* CHECK dout0_26 Vdout0_26ck82 = 1.8 time = 1660
.meas tran vdout0_26ck82 FIND v(dout0_26) AT=1660.1n

* CHECK dout0_27 Vdout0_27ck82 = 0 time = 1660
.meas tran vdout0_27ck82 FIND v(dout0_27) AT=1660.1n

* CHECK dout0_28 Vdout0_28ck82 = 1.8 time = 1660
.meas tran vdout0_28ck82 FIND v(dout0_28) AT=1660.1n

* CHECK dout0_29 Vdout0_29ck82 = 1.8 time = 1660
.meas tran vdout0_29ck82 FIND v(dout0_29) AT=1660.1n

* CHECK dout0_30 Vdout0_30ck82 = 1.8 time = 1660
.meas tran vdout0_30ck82 FIND v(dout0_30) AT=1660.1n

* CHECK dout0_31 Vdout0_31ck82 = 0 time = 1660
.meas tran vdout0_31ck82 FIND v(dout0_31) AT=1660.1n

* CHECK dout0_0 Vdout0_0ck83 = 1.8 time = 1680
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=1680.1n

* CHECK dout0_1 Vdout0_1ck83 = 1.8 time = 1680
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=1680.1n

* CHECK dout0_2 Vdout0_2ck83 = 1.8 time = 1680
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=1680.1n

* CHECK dout0_3 Vdout0_3ck83 = 1.8 time = 1680
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=1680.1n

* CHECK dout0_4 Vdout0_4ck83 = 0 time = 1680
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=1680.1n

* CHECK dout0_5 Vdout0_5ck83 = 0 time = 1680
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=1680.1n

* CHECK dout0_6 Vdout0_6ck83 = 1.8 time = 1680
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=1680.1n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 1680
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=1680.1n

* CHECK dout0_8 Vdout0_8ck83 = 0 time = 1680
.meas tran vdout0_8ck83 FIND v(dout0_8) AT=1680.1n

* CHECK dout0_9 Vdout0_9ck83 = 0 time = 1680
.meas tran vdout0_9ck83 FIND v(dout0_9) AT=1680.1n

* CHECK dout0_10 Vdout0_10ck83 = 0 time = 1680
.meas tran vdout0_10ck83 FIND v(dout0_10) AT=1680.1n

* CHECK dout0_11 Vdout0_11ck83 = 1.8 time = 1680
.meas tran vdout0_11ck83 FIND v(dout0_11) AT=1680.1n

* CHECK dout0_12 Vdout0_12ck83 = 1.8 time = 1680
.meas tran vdout0_12ck83 FIND v(dout0_12) AT=1680.1n

* CHECK dout0_13 Vdout0_13ck83 = 0 time = 1680
.meas tran vdout0_13ck83 FIND v(dout0_13) AT=1680.1n

* CHECK dout0_14 Vdout0_14ck83 = 1.8 time = 1680
.meas tran vdout0_14ck83 FIND v(dout0_14) AT=1680.1n

* CHECK dout0_15 Vdout0_15ck83 = 1.8 time = 1680
.meas tran vdout0_15ck83 FIND v(dout0_15) AT=1680.1n

* CHECK dout0_16 Vdout0_16ck83 = 1.8 time = 1680
.meas tran vdout0_16ck83 FIND v(dout0_16) AT=1680.1n

* CHECK dout0_17 Vdout0_17ck83 = 1.8 time = 1680
.meas tran vdout0_17ck83 FIND v(dout0_17) AT=1680.1n

* CHECK dout0_18 Vdout0_18ck83 = 1.8 time = 1680
.meas tran vdout0_18ck83 FIND v(dout0_18) AT=1680.1n

* CHECK dout0_19 Vdout0_19ck83 = 0 time = 1680
.meas tran vdout0_19ck83 FIND v(dout0_19) AT=1680.1n

* CHECK dout0_20 Vdout0_20ck83 = 1.8 time = 1680
.meas tran vdout0_20ck83 FIND v(dout0_20) AT=1680.1n

* CHECK dout0_21 Vdout0_21ck83 = 1.8 time = 1680
.meas tran vdout0_21ck83 FIND v(dout0_21) AT=1680.1n

* CHECK dout0_22 Vdout0_22ck83 = 1.8 time = 1680
.meas tran vdout0_22ck83 FIND v(dout0_22) AT=1680.1n

* CHECK dout0_23 Vdout0_23ck83 = 0 time = 1680
.meas tran vdout0_23ck83 FIND v(dout0_23) AT=1680.1n

* CHECK dout0_24 Vdout0_24ck83 = 1.8 time = 1680
.meas tran vdout0_24ck83 FIND v(dout0_24) AT=1680.1n

* CHECK dout0_25 Vdout0_25ck83 = 0 time = 1680
.meas tran vdout0_25ck83 FIND v(dout0_25) AT=1680.1n

* CHECK dout0_26 Vdout0_26ck83 = 0 time = 1680
.meas tran vdout0_26ck83 FIND v(dout0_26) AT=1680.1n

* CHECK dout0_27 Vdout0_27ck83 = 0 time = 1680
.meas tran vdout0_27ck83 FIND v(dout0_27) AT=1680.1n

* CHECK dout0_28 Vdout0_28ck83 = 1.8 time = 1680
.meas tran vdout0_28ck83 FIND v(dout0_28) AT=1680.1n

* CHECK dout0_29 Vdout0_29ck83 = 0 time = 1680
.meas tran vdout0_29ck83 FIND v(dout0_29) AT=1680.1n

* CHECK dout0_30 Vdout0_30ck83 = 1.8 time = 1680
.meas tran vdout0_30ck83 FIND v(dout0_30) AT=1680.1n

* CHECK dout0_31 Vdout0_31ck83 = 1.8 time = 1680
.meas tran vdout0_31ck83 FIND v(dout0_31) AT=1680.1n

* CHECK dout0_0 Vdout0_0ck86 = 0 time = 1740
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=1740.1n

* CHECK dout0_1 Vdout0_1ck86 = 0 time = 1740
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=1740.1n

* CHECK dout0_2 Vdout0_2ck86 = 0 time = 1740
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=1740.1n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 1740
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=1740.1n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 1740
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=1740.1n

* CHECK dout0_5 Vdout0_5ck86 = 0 time = 1740
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=1740.1n

* CHECK dout0_6 Vdout0_6ck86 = 0 time = 1740
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=1740.1n

* CHECK dout0_7 Vdout0_7ck86 = 1.8 time = 1740
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=1740.1n

* CHECK dout0_8 Vdout0_8ck86 = 1.8 time = 1740
.meas tran vdout0_8ck86 FIND v(dout0_8) AT=1740.1n

* CHECK dout0_9 Vdout0_9ck86 = 0 time = 1740
.meas tran vdout0_9ck86 FIND v(dout0_9) AT=1740.1n

* CHECK dout0_10 Vdout0_10ck86 = 0 time = 1740
.meas tran vdout0_10ck86 FIND v(dout0_10) AT=1740.1n

* CHECK dout0_11 Vdout0_11ck86 = 1.8 time = 1740
.meas tran vdout0_11ck86 FIND v(dout0_11) AT=1740.1n

* CHECK dout0_12 Vdout0_12ck86 = 0 time = 1740
.meas tran vdout0_12ck86 FIND v(dout0_12) AT=1740.1n

* CHECK dout0_13 Vdout0_13ck86 = 1.8 time = 1740
.meas tran vdout0_13ck86 FIND v(dout0_13) AT=1740.1n

* CHECK dout0_14 Vdout0_14ck86 = 1.8 time = 1740
.meas tran vdout0_14ck86 FIND v(dout0_14) AT=1740.1n

* CHECK dout0_15 Vdout0_15ck86 = 0 time = 1740
.meas tran vdout0_15ck86 FIND v(dout0_15) AT=1740.1n

* CHECK dout0_16 Vdout0_16ck86 = 1.8 time = 1740
.meas tran vdout0_16ck86 FIND v(dout0_16) AT=1740.1n

* CHECK dout0_17 Vdout0_17ck86 = 1.8 time = 1740
.meas tran vdout0_17ck86 FIND v(dout0_17) AT=1740.1n

* CHECK dout0_18 Vdout0_18ck86 = 1.8 time = 1740
.meas tran vdout0_18ck86 FIND v(dout0_18) AT=1740.1n

* CHECK dout0_19 Vdout0_19ck86 = 1.8 time = 1740
.meas tran vdout0_19ck86 FIND v(dout0_19) AT=1740.1n

* CHECK dout0_20 Vdout0_20ck86 = 0 time = 1740
.meas tran vdout0_20ck86 FIND v(dout0_20) AT=1740.1n

* CHECK dout0_21 Vdout0_21ck86 = 1.8 time = 1740
.meas tran vdout0_21ck86 FIND v(dout0_21) AT=1740.1n

* CHECK dout0_22 Vdout0_22ck86 = 0 time = 1740
.meas tran vdout0_22ck86 FIND v(dout0_22) AT=1740.1n

* CHECK dout0_23 Vdout0_23ck86 = 1.8 time = 1740
.meas tran vdout0_23ck86 FIND v(dout0_23) AT=1740.1n

* CHECK dout0_24 Vdout0_24ck86 = 1.8 time = 1740
.meas tran vdout0_24ck86 FIND v(dout0_24) AT=1740.1n

* CHECK dout0_25 Vdout0_25ck86 = 1.8 time = 1740
.meas tran vdout0_25ck86 FIND v(dout0_25) AT=1740.1n

* CHECK dout0_26 Vdout0_26ck86 = 1.8 time = 1740
.meas tran vdout0_26ck86 FIND v(dout0_26) AT=1740.1n

* CHECK dout0_27 Vdout0_27ck86 = 0 time = 1740
.meas tran vdout0_27ck86 FIND v(dout0_27) AT=1740.1n

* CHECK dout0_28 Vdout0_28ck86 = 1.8 time = 1740
.meas tran vdout0_28ck86 FIND v(dout0_28) AT=1740.1n

* CHECK dout0_29 Vdout0_29ck86 = 0 time = 1740
.meas tran vdout0_29ck86 FIND v(dout0_29) AT=1740.1n

* CHECK dout0_30 Vdout0_30ck86 = 0 time = 1740
.meas tran vdout0_30ck86 FIND v(dout0_30) AT=1740.1n

* CHECK dout0_31 Vdout0_31ck86 = 1.8 time = 1740
.meas tran vdout0_31ck86 FIND v(dout0_31) AT=1740.1n

* CHECK dout0_0 Vdout0_0ck91 = 0 time = 1840
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=1840.1n

* CHECK dout0_1 Vdout0_1ck91 = 0 time = 1840
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=1840.1n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 1840
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=1840.1n

* CHECK dout0_3 Vdout0_3ck91 = 0 time = 1840
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=1840.1n

* CHECK dout0_4 Vdout0_4ck91 = 1.8 time = 1840
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=1840.1n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 1840
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=1840.1n

* CHECK dout0_6 Vdout0_6ck91 = 0 time = 1840
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=1840.1n

* CHECK dout0_7 Vdout0_7ck91 = 0 time = 1840
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=1840.1n

* CHECK dout0_8 Vdout0_8ck91 = 0 time = 1840
.meas tran vdout0_8ck91 FIND v(dout0_8) AT=1840.1n

* CHECK dout0_9 Vdout0_9ck91 = 1.8 time = 1840
.meas tran vdout0_9ck91 FIND v(dout0_9) AT=1840.1n

* CHECK dout0_10 Vdout0_10ck91 = 0 time = 1840
.meas tran vdout0_10ck91 FIND v(dout0_10) AT=1840.1n

* CHECK dout0_11 Vdout0_11ck91 = 0 time = 1840
.meas tran vdout0_11ck91 FIND v(dout0_11) AT=1840.1n

* CHECK dout0_12 Vdout0_12ck91 = 0 time = 1840
.meas tran vdout0_12ck91 FIND v(dout0_12) AT=1840.1n

* CHECK dout0_13 Vdout0_13ck91 = 1.8 time = 1840
.meas tran vdout0_13ck91 FIND v(dout0_13) AT=1840.1n

* CHECK dout0_14 Vdout0_14ck91 = 0 time = 1840
.meas tran vdout0_14ck91 FIND v(dout0_14) AT=1840.1n

* CHECK dout0_15 Vdout0_15ck91 = 0 time = 1840
.meas tran vdout0_15ck91 FIND v(dout0_15) AT=1840.1n

* CHECK dout0_16 Vdout0_16ck91 = 0 time = 1840
.meas tran vdout0_16ck91 FIND v(dout0_16) AT=1840.1n

* CHECK dout0_17 Vdout0_17ck91 = 1.8 time = 1840
.meas tran vdout0_17ck91 FIND v(dout0_17) AT=1840.1n

* CHECK dout0_18 Vdout0_18ck91 = 1.8 time = 1840
.meas tran vdout0_18ck91 FIND v(dout0_18) AT=1840.1n

* CHECK dout0_19 Vdout0_19ck91 = 0 time = 1840
.meas tran vdout0_19ck91 FIND v(dout0_19) AT=1840.1n

* CHECK dout0_20 Vdout0_20ck91 = 1.8 time = 1840
.meas tran vdout0_20ck91 FIND v(dout0_20) AT=1840.1n

* CHECK dout0_21 Vdout0_21ck91 = 0 time = 1840
.meas tran vdout0_21ck91 FIND v(dout0_21) AT=1840.1n

* CHECK dout0_22 Vdout0_22ck91 = 1.8 time = 1840
.meas tran vdout0_22ck91 FIND v(dout0_22) AT=1840.1n

* CHECK dout0_23 Vdout0_23ck91 = 1.8 time = 1840
.meas tran vdout0_23ck91 FIND v(dout0_23) AT=1840.1n

* CHECK dout0_24 Vdout0_24ck91 = 0 time = 1840
.meas tran vdout0_24ck91 FIND v(dout0_24) AT=1840.1n

* CHECK dout0_25 Vdout0_25ck91 = 1.8 time = 1840
.meas tran vdout0_25ck91 FIND v(dout0_25) AT=1840.1n

* CHECK dout0_26 Vdout0_26ck91 = 0 time = 1840
.meas tran vdout0_26ck91 FIND v(dout0_26) AT=1840.1n

* CHECK dout0_27 Vdout0_27ck91 = 0 time = 1840
.meas tran vdout0_27ck91 FIND v(dout0_27) AT=1840.1n

* CHECK dout0_28 Vdout0_28ck91 = 1.8 time = 1840
.meas tran vdout0_28ck91 FIND v(dout0_28) AT=1840.1n

* CHECK dout0_29 Vdout0_29ck91 = 1.8 time = 1840
.meas tran vdout0_29ck91 FIND v(dout0_29) AT=1840.1n

* CHECK dout0_30 Vdout0_30ck91 = 1.8 time = 1840
.meas tran vdout0_30ck91 FIND v(dout0_30) AT=1840.1n

* CHECK dout0_31 Vdout0_31ck91 = 0 time = 1840
.meas tran vdout0_31ck91 FIND v(dout0_31) AT=1840.1n

* CHECK dout0_0 Vdout0_0ck92 = 0 time = 1860
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=1860.1n

* CHECK dout0_1 Vdout0_1ck92 = 1.8 time = 1860
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=1860.1n

* CHECK dout0_2 Vdout0_2ck92 = 1.8 time = 1860
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=1860.1n

* CHECK dout0_3 Vdout0_3ck92 = 1.8 time = 1860
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=1860.1n

* CHECK dout0_4 Vdout0_4ck92 = 0 time = 1860
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=1860.1n

* CHECK dout0_5 Vdout0_5ck92 = 1.8 time = 1860
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=1860.1n

* CHECK dout0_6 Vdout0_6ck92 = 0 time = 1860
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=1860.1n

* CHECK dout0_7 Vdout0_7ck92 = 1.8 time = 1860
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=1860.1n

* CHECK dout0_8 Vdout0_8ck92 = 0 time = 1860
.meas tran vdout0_8ck92 FIND v(dout0_8) AT=1860.1n

* CHECK dout0_9 Vdout0_9ck92 = 1.8 time = 1860
.meas tran vdout0_9ck92 FIND v(dout0_9) AT=1860.1n

* CHECK dout0_10 Vdout0_10ck92 = 1.8 time = 1860
.meas tran vdout0_10ck92 FIND v(dout0_10) AT=1860.1n

* CHECK dout0_11 Vdout0_11ck92 = 1.8 time = 1860
.meas tran vdout0_11ck92 FIND v(dout0_11) AT=1860.1n

* CHECK dout0_12 Vdout0_12ck92 = 0 time = 1860
.meas tran vdout0_12ck92 FIND v(dout0_12) AT=1860.1n

* CHECK dout0_13 Vdout0_13ck92 = 0 time = 1860
.meas tran vdout0_13ck92 FIND v(dout0_13) AT=1860.1n

* CHECK dout0_14 Vdout0_14ck92 = 0 time = 1860
.meas tran vdout0_14ck92 FIND v(dout0_14) AT=1860.1n

* CHECK dout0_15 Vdout0_15ck92 = 0 time = 1860
.meas tran vdout0_15ck92 FIND v(dout0_15) AT=1860.1n

* CHECK dout0_16 Vdout0_16ck92 = 0 time = 1860
.meas tran vdout0_16ck92 FIND v(dout0_16) AT=1860.1n

* CHECK dout0_17 Vdout0_17ck92 = 0 time = 1860
.meas tran vdout0_17ck92 FIND v(dout0_17) AT=1860.1n

* CHECK dout0_18 Vdout0_18ck92 = 0 time = 1860
.meas tran vdout0_18ck92 FIND v(dout0_18) AT=1860.1n

* CHECK dout0_19 Vdout0_19ck92 = 0 time = 1860
.meas tran vdout0_19ck92 FIND v(dout0_19) AT=1860.1n

* CHECK dout0_20 Vdout0_20ck92 = 1.8 time = 1860
.meas tran vdout0_20ck92 FIND v(dout0_20) AT=1860.1n

* CHECK dout0_21 Vdout0_21ck92 = 1.8 time = 1860
.meas tran vdout0_21ck92 FIND v(dout0_21) AT=1860.1n

* CHECK dout0_22 Vdout0_22ck92 = 0 time = 1860
.meas tran vdout0_22ck92 FIND v(dout0_22) AT=1860.1n

* CHECK dout0_23 Vdout0_23ck92 = 1.8 time = 1860
.meas tran vdout0_23ck92 FIND v(dout0_23) AT=1860.1n

* CHECK dout0_24 Vdout0_24ck92 = 1.8 time = 1860
.meas tran vdout0_24ck92 FIND v(dout0_24) AT=1860.1n

* CHECK dout0_25 Vdout0_25ck92 = 0 time = 1860
.meas tran vdout0_25ck92 FIND v(dout0_25) AT=1860.1n

* CHECK dout0_26 Vdout0_26ck92 = 0 time = 1860
.meas tran vdout0_26ck92 FIND v(dout0_26) AT=1860.1n

* CHECK dout0_27 Vdout0_27ck92 = 0 time = 1860
.meas tran vdout0_27ck92 FIND v(dout0_27) AT=1860.1n

* CHECK dout0_28 Vdout0_28ck92 = 1.8 time = 1860
.meas tran vdout0_28ck92 FIND v(dout0_28) AT=1860.1n

* CHECK dout0_29 Vdout0_29ck92 = 0 time = 1860
.meas tran vdout0_29ck92 FIND v(dout0_29) AT=1860.1n

* CHECK dout0_30 Vdout0_30ck92 = 0 time = 1860
.meas tran vdout0_30ck92 FIND v(dout0_30) AT=1860.1n

* CHECK dout0_31 Vdout0_31ck92 = 1.8 time = 1860
.meas tran vdout0_31ck92 FIND v(dout0_31) AT=1860.1n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 1880
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=1880.1n

* CHECK dout0_1 Vdout0_1ck93 = 1.8 time = 1880
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=1880.1n

* CHECK dout0_2 Vdout0_2ck93 = 0 time = 1880
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=1880.1n

* CHECK dout0_3 Vdout0_3ck93 = 1.8 time = 1880
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=1880.1n

* CHECK dout0_4 Vdout0_4ck93 = 1.8 time = 1880
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=1880.1n

* CHECK dout0_5 Vdout0_5ck93 = 0 time = 1880
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=1880.1n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 1880
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=1880.1n

* CHECK dout0_7 Vdout0_7ck93 = 0 time = 1880
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=1880.1n

* CHECK dout0_8 Vdout0_8ck93 = 0 time = 1880
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=1880.1n

* CHECK dout0_9 Vdout0_9ck93 = 1.8 time = 1880
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=1880.1n

* CHECK dout0_10 Vdout0_10ck93 = 1.8 time = 1880
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=1880.1n

* CHECK dout0_11 Vdout0_11ck93 = 1.8 time = 1880
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=1880.1n

* CHECK dout0_12 Vdout0_12ck93 = 1.8 time = 1880
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=1880.1n

* CHECK dout0_13 Vdout0_13ck93 = 1.8 time = 1880
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=1880.1n

* CHECK dout0_14 Vdout0_14ck93 = 1.8 time = 1880
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=1880.1n

* CHECK dout0_15 Vdout0_15ck93 = 1.8 time = 1880
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=1880.1n

* CHECK dout0_16 Vdout0_16ck93 = 1.8 time = 1880
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=1880.1n

* CHECK dout0_17 Vdout0_17ck93 = 1.8 time = 1880
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=1880.1n

* CHECK dout0_18 Vdout0_18ck93 = 0 time = 1880
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=1880.1n

* CHECK dout0_19 Vdout0_19ck93 = 1.8 time = 1880
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=1880.1n

* CHECK dout0_20 Vdout0_20ck93 = 1.8 time = 1880
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=1880.1n

* CHECK dout0_21 Vdout0_21ck93 = 1.8 time = 1880
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=1880.1n

* CHECK dout0_22 Vdout0_22ck93 = 0 time = 1880
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=1880.1n

* CHECK dout0_23 Vdout0_23ck93 = 0 time = 1880
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=1880.1n

* CHECK dout0_24 Vdout0_24ck93 = 1.8 time = 1880
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=1880.1n

* CHECK dout0_25 Vdout0_25ck93 = 0 time = 1880
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=1880.1n

* CHECK dout0_26 Vdout0_26ck93 = 1.8 time = 1880
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=1880.1n

* CHECK dout0_27 Vdout0_27ck93 = 0 time = 1880
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=1880.1n

* CHECK dout0_28 Vdout0_28ck93 = 0 time = 1880
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=1880.1n

* CHECK dout0_29 Vdout0_29ck93 = 0 time = 1880
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=1880.1n

* CHECK dout0_30 Vdout0_30ck93 = 1.8 time = 1880
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=1880.1n

* CHECK dout0_31 Vdout0_31ck93 = 0 time = 1880
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=1880.1n

* CHECK dout0_0 Vdout0_0ck95 = 0 time = 1920
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=1920.1n

* CHECK dout0_1 Vdout0_1ck95 = 1.8 time = 1920
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=1920.1n

* CHECK dout0_2 Vdout0_2ck95 = 0 time = 1920
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=1920.1n

* CHECK dout0_3 Vdout0_3ck95 = 0 time = 1920
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=1920.1n

* CHECK dout0_4 Vdout0_4ck95 = 1.8 time = 1920
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=1920.1n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 1920
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=1920.1n

* CHECK dout0_6 Vdout0_6ck95 = 0 time = 1920
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=1920.1n

* CHECK dout0_7 Vdout0_7ck95 = 1.8 time = 1920
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=1920.1n

* CHECK dout0_8 Vdout0_8ck95 = 1.8 time = 1920
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=1920.1n

* CHECK dout0_9 Vdout0_9ck95 = 1.8 time = 1920
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=1920.1n

* CHECK dout0_10 Vdout0_10ck95 = 1.8 time = 1920
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=1920.1n

* CHECK dout0_11 Vdout0_11ck95 = 0 time = 1920
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=1920.1n

* CHECK dout0_12 Vdout0_12ck95 = 0 time = 1920
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=1920.1n

* CHECK dout0_13 Vdout0_13ck95 = 1.8 time = 1920
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=1920.1n

* CHECK dout0_14 Vdout0_14ck95 = 0 time = 1920
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=1920.1n

* CHECK dout0_15 Vdout0_15ck95 = 0 time = 1920
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=1920.1n

* CHECK dout0_16 Vdout0_16ck95 = 0 time = 1920
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=1920.1n

* CHECK dout0_17 Vdout0_17ck95 = 0 time = 1920
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=1920.1n

* CHECK dout0_18 Vdout0_18ck95 = 0 time = 1920
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=1920.1n

* CHECK dout0_19 Vdout0_19ck95 = 1.8 time = 1920
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=1920.1n

* CHECK dout0_20 Vdout0_20ck95 = 0 time = 1920
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=1920.1n

* CHECK dout0_21 Vdout0_21ck95 = 1.8 time = 1920
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=1920.1n

* CHECK dout0_22 Vdout0_22ck95 = 0 time = 1920
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=1920.1n

* CHECK dout0_23 Vdout0_23ck95 = 1.8 time = 1920
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=1920.1n

* CHECK dout0_24 Vdout0_24ck95 = 1.8 time = 1920
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=1920.1n

* CHECK dout0_25 Vdout0_25ck95 = 1.8 time = 1920
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=1920.1n

* CHECK dout0_26 Vdout0_26ck95 = 1.8 time = 1920
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=1920.1n

* CHECK dout0_27 Vdout0_27ck95 = 0 time = 1920
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=1920.1n

* CHECK dout0_28 Vdout0_28ck95 = 0 time = 1920
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=1920.1n

* CHECK dout0_29 Vdout0_29ck95 = 1.8 time = 1920
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=1920.1n

* CHECK dout0_30 Vdout0_30ck95 = 1.8 time = 1920
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=1920.1n

* CHECK dout0_31 Vdout0_31ck95 = 0 time = 1920
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=1920.1n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 1940
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=1940.1n

* CHECK dout0_1 Vdout0_1ck96 = 0 time = 1940
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=1940.1n

* CHECK dout0_2 Vdout0_2ck96 = 0 time = 1940
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=1940.1n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 1940
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=1940.1n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 1940
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=1940.1n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 1940
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=1940.1n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 1940
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=1940.1n

* CHECK dout0_7 Vdout0_7ck96 = 1.8 time = 1940
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=1940.1n

* CHECK dout0_8 Vdout0_8ck96 = 1.8 time = 1940
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=1940.1n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 1940
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=1940.1n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 1940
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=1940.1n

* CHECK dout0_11 Vdout0_11ck96 = 1.8 time = 1940
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=1940.1n

* CHECK dout0_12 Vdout0_12ck96 = 0 time = 1940
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=1940.1n

* CHECK dout0_13 Vdout0_13ck96 = 1.8 time = 1940
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=1940.1n

* CHECK dout0_14 Vdout0_14ck96 = 1.8 time = 1940
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=1940.1n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 1940
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=1940.1n

* CHECK dout0_16 Vdout0_16ck96 = 1.8 time = 1940
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=1940.1n

* CHECK dout0_17 Vdout0_17ck96 = 1.8 time = 1940
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=1940.1n

* CHECK dout0_18 Vdout0_18ck96 = 1.8 time = 1940
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=1940.1n

* CHECK dout0_19 Vdout0_19ck96 = 1.8 time = 1940
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=1940.1n

* CHECK dout0_20 Vdout0_20ck96 = 0 time = 1940
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=1940.1n

* CHECK dout0_21 Vdout0_21ck96 = 1.8 time = 1940
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=1940.1n

* CHECK dout0_22 Vdout0_22ck96 = 0 time = 1940
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=1940.1n

* CHECK dout0_23 Vdout0_23ck96 = 1.8 time = 1940
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=1940.1n

* CHECK dout0_24 Vdout0_24ck96 = 1.8 time = 1940
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=1940.1n

* CHECK dout0_25 Vdout0_25ck96 = 1.8 time = 1940
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=1940.1n

* CHECK dout0_26 Vdout0_26ck96 = 1.8 time = 1940
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=1940.1n

* CHECK dout0_27 Vdout0_27ck96 = 0 time = 1940
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=1940.1n

* CHECK dout0_28 Vdout0_28ck96 = 1.8 time = 1940
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=1940.1n

* CHECK dout0_29 Vdout0_29ck96 = 0 time = 1940
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=1940.1n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 1940
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=1940.1n

* CHECK dout0_31 Vdout0_31ck96 = 1.8 time = 1940
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=1940.1n

* CHECK dout0_0 Vdout0_0ck97 = 1.8 time = 1960
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=1960.1n

* CHECK dout0_1 Vdout0_1ck97 = 0 time = 1960
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=1960.1n

* CHECK dout0_2 Vdout0_2ck97 = 0 time = 1960
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=1960.1n

* CHECK dout0_3 Vdout0_3ck97 = 1.8 time = 1960
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=1960.1n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 1960
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=1960.1n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 1960
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=1960.1n

* CHECK dout0_6 Vdout0_6ck97 = 0 time = 1960
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=1960.1n

* CHECK dout0_7 Vdout0_7ck97 = 1.8 time = 1960
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=1960.1n

* CHECK dout0_8 Vdout0_8ck97 = 1.8 time = 1960
.meas tran vdout0_8ck97 FIND v(dout0_8) AT=1960.1n

* CHECK dout0_9 Vdout0_9ck97 = 1.8 time = 1960
.meas tran vdout0_9ck97 FIND v(dout0_9) AT=1960.1n

* CHECK dout0_10 Vdout0_10ck97 = 0 time = 1960
.meas tran vdout0_10ck97 FIND v(dout0_10) AT=1960.1n

* CHECK dout0_11 Vdout0_11ck97 = 0 time = 1960
.meas tran vdout0_11ck97 FIND v(dout0_11) AT=1960.1n

* CHECK dout0_12 Vdout0_12ck97 = 1.8 time = 1960
.meas tran vdout0_12ck97 FIND v(dout0_12) AT=1960.1n

* CHECK dout0_13 Vdout0_13ck97 = 1.8 time = 1960
.meas tran vdout0_13ck97 FIND v(dout0_13) AT=1960.1n

* CHECK dout0_14 Vdout0_14ck97 = 1.8 time = 1960
.meas tran vdout0_14ck97 FIND v(dout0_14) AT=1960.1n

* CHECK dout0_15 Vdout0_15ck97 = 1.8 time = 1960
.meas tran vdout0_15ck97 FIND v(dout0_15) AT=1960.1n

* CHECK dout0_16 Vdout0_16ck97 = 1.8 time = 1960
.meas tran vdout0_16ck97 FIND v(dout0_16) AT=1960.1n

* CHECK dout0_17 Vdout0_17ck97 = 0 time = 1960
.meas tran vdout0_17ck97 FIND v(dout0_17) AT=1960.1n

* CHECK dout0_18 Vdout0_18ck97 = 0 time = 1960
.meas tran vdout0_18ck97 FIND v(dout0_18) AT=1960.1n

* CHECK dout0_19 Vdout0_19ck97 = 0 time = 1960
.meas tran vdout0_19ck97 FIND v(dout0_19) AT=1960.1n

* CHECK dout0_20 Vdout0_20ck97 = 0 time = 1960
.meas tran vdout0_20ck97 FIND v(dout0_20) AT=1960.1n

* CHECK dout0_21 Vdout0_21ck97 = 0 time = 1960
.meas tran vdout0_21ck97 FIND v(dout0_21) AT=1960.1n

* CHECK dout0_22 Vdout0_22ck97 = 1.8 time = 1960
.meas tran vdout0_22ck97 FIND v(dout0_22) AT=1960.1n

* CHECK dout0_23 Vdout0_23ck97 = 1.8 time = 1960
.meas tran vdout0_23ck97 FIND v(dout0_23) AT=1960.1n

* CHECK dout0_24 Vdout0_24ck97 = 1.8 time = 1960
.meas tran vdout0_24ck97 FIND v(dout0_24) AT=1960.1n

* CHECK dout0_25 Vdout0_25ck97 = 1.8 time = 1960
.meas tran vdout0_25ck97 FIND v(dout0_25) AT=1960.1n

* CHECK dout0_26 Vdout0_26ck97 = 0 time = 1960
.meas tran vdout0_26ck97 FIND v(dout0_26) AT=1960.1n

* CHECK dout0_27 Vdout0_27ck97 = 0 time = 1960
.meas tran vdout0_27ck97 FIND v(dout0_27) AT=1960.1n

* CHECK dout0_28 Vdout0_28ck97 = 0 time = 1960
.meas tran vdout0_28ck97 FIND v(dout0_28) AT=1960.1n

* CHECK dout0_29 Vdout0_29ck97 = 1.8 time = 1960
.meas tran vdout0_29ck97 FIND v(dout0_29) AT=1960.1n

* CHECK dout0_30 Vdout0_30ck97 = 0 time = 1960
.meas tran vdout0_30ck97 FIND v(dout0_30) AT=1960.1n

* CHECK dout0_31 Vdout0_31ck97 = 0 time = 1960
.meas tran vdout0_31ck97 FIND v(dout0_31) AT=1960.1n

* CHECK dout0_0 Vdout0_0ck99 = 1.8 time = 2000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=2000.1n

* CHECK dout0_1 Vdout0_1ck99 = 0 time = 2000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=2000.1n

* CHECK dout0_2 Vdout0_2ck99 = 1.8 time = 2000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=2000.1n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 2000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=2000.1n

* CHECK dout0_4 Vdout0_4ck99 = 1.8 time = 2000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=2000.1n

* CHECK dout0_5 Vdout0_5ck99 = 1.8 time = 2000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=2000.1n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 2000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=2000.1n

* CHECK dout0_7 Vdout0_7ck99 = 0 time = 2000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=2000.1n

* CHECK dout0_8 Vdout0_8ck99 = 1.8 time = 2000
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=2000.1n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 2000
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=2000.1n

* CHECK dout0_10 Vdout0_10ck99 = 1.8 time = 2000
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=2000.1n

* CHECK dout0_11 Vdout0_11ck99 = 0 time = 2000
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=2000.1n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 2000
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=2000.1n

* CHECK dout0_13 Vdout0_13ck99 = 1.8 time = 2000
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=2000.1n

* CHECK dout0_14 Vdout0_14ck99 = 1.8 time = 2000
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=2000.1n

* CHECK dout0_15 Vdout0_15ck99 = 1.8 time = 2000
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=2000.1n

* CHECK dout0_16 Vdout0_16ck99 = 0 time = 2000
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=2000.1n

* CHECK dout0_17 Vdout0_17ck99 = 1.8 time = 2000
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=2000.1n

* CHECK dout0_18 Vdout0_18ck99 = 0 time = 2000
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=2000.1n

* CHECK dout0_19 Vdout0_19ck99 = 0 time = 2000
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=2000.1n

* CHECK dout0_20 Vdout0_20ck99 = 1.8 time = 2000
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=2000.1n

* CHECK dout0_21 Vdout0_21ck99 = 1.8 time = 2000
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=2000.1n

* CHECK dout0_22 Vdout0_22ck99 = 1.8 time = 2000
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=2000.1n

* CHECK dout0_23 Vdout0_23ck99 = 1.8 time = 2000
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=2000.1n

* CHECK dout0_24 Vdout0_24ck99 = 1.8 time = 2000
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=2000.1n

* CHECK dout0_25 Vdout0_25ck99 = 0 time = 2000
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=2000.1n

* CHECK dout0_26 Vdout0_26ck99 = 1.8 time = 2000
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=2000.1n

* CHECK dout0_27 Vdout0_27ck99 = 1.8 time = 2000
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=2000.1n

* CHECK dout0_28 Vdout0_28ck99 = 1.8 time = 2000
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=2000.1n

* CHECK dout0_29 Vdout0_29ck99 = 1.8 time = 2000
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=2000.1n

* CHECK dout0_30 Vdout0_30ck99 = 1.8 time = 2000
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=2000.1n

* CHECK dout0_31 Vdout0_31ck99 = 1.8 time = 2000
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=2000.1n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 2060
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=2060.1n

* CHECK dout0_1 Vdout0_1ck102 = 0 time = 2060
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=2060.1n

* CHECK dout0_2 Vdout0_2ck102 = 1.8 time = 2060
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=2060.1n

* CHECK dout0_3 Vdout0_3ck102 = 1.8 time = 2060
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=2060.1n

* CHECK dout0_4 Vdout0_4ck102 = 1.8 time = 2060
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=2060.1n

* CHECK dout0_5 Vdout0_5ck102 = 1.8 time = 2060
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=2060.1n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 2060
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=2060.1n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 2060
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=2060.1n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 2060
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=2060.1n

* CHECK dout0_9 Vdout0_9ck102 = 1.8 time = 2060
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=2060.1n

* CHECK dout0_10 Vdout0_10ck102 = 0 time = 2060
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=2060.1n

* CHECK dout0_11 Vdout0_11ck102 = 0 time = 2060
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=2060.1n

* CHECK dout0_12 Vdout0_12ck102 = 1.8 time = 2060
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=2060.1n

* CHECK dout0_13 Vdout0_13ck102 = 1.8 time = 2060
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=2060.1n

* CHECK dout0_14 Vdout0_14ck102 = 1.8 time = 2060
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=2060.1n

* CHECK dout0_15 Vdout0_15ck102 = 0 time = 2060
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=2060.1n

* CHECK dout0_16 Vdout0_16ck102 = 1.8 time = 2060
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=2060.1n

* CHECK dout0_17 Vdout0_17ck102 = 0 time = 2060
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=2060.1n

* CHECK dout0_18 Vdout0_18ck102 = 1.8 time = 2060
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=2060.1n

* CHECK dout0_19 Vdout0_19ck102 = 0 time = 2060
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=2060.1n

* CHECK dout0_20 Vdout0_20ck102 = 0 time = 2060
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=2060.1n

* CHECK dout0_21 Vdout0_21ck102 = 0 time = 2060
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=2060.1n

* CHECK dout0_22 Vdout0_22ck102 = 0 time = 2060
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=2060.1n

* CHECK dout0_23 Vdout0_23ck102 = 1.8 time = 2060
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=2060.1n

* CHECK dout0_24 Vdout0_24ck102 = 1.8 time = 2060
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=2060.1n

* CHECK dout0_25 Vdout0_25ck102 = 1.8 time = 2060
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=2060.1n

* CHECK dout0_26 Vdout0_26ck102 = 1.8 time = 2060
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=2060.1n

* CHECK dout0_27 Vdout0_27ck102 = 1.8 time = 2060
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=2060.1n

* CHECK dout0_28 Vdout0_28ck102 = 0 time = 2060
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=2060.1n

* CHECK dout0_29 Vdout0_29ck102 = 0 time = 2060
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=2060.1n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 2060
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=2060.1n

* CHECK dout0_31 Vdout0_31ck102 = 1.8 time = 2060
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=2060.1n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 2120
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=2120.1n

* CHECK dout0_1 Vdout0_1ck105 = 1.8 time = 2120
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=2120.1n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 2120
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=2120.1n

* CHECK dout0_3 Vdout0_3ck105 = 1.8 time = 2120
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=2120.1n

* CHECK dout0_4 Vdout0_4ck105 = 1.8 time = 2120
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=2120.1n

* CHECK dout0_5 Vdout0_5ck105 = 0 time = 2120
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=2120.1n

* CHECK dout0_6 Vdout0_6ck105 = 0 time = 2120
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=2120.1n

* CHECK dout0_7 Vdout0_7ck105 = 1.8 time = 2120
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=2120.1n

* CHECK dout0_8 Vdout0_8ck105 = 1.8 time = 2120
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=2120.1n

* CHECK dout0_9 Vdout0_9ck105 = 0 time = 2120
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=2120.1n

* CHECK dout0_10 Vdout0_10ck105 = 1.8 time = 2120
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=2120.1n

* CHECK dout0_11 Vdout0_11ck105 = 1.8 time = 2120
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=2120.1n

* CHECK dout0_12 Vdout0_12ck105 = 0 time = 2120
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=2120.1n

* CHECK dout0_13 Vdout0_13ck105 = 1.8 time = 2120
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=2120.1n

* CHECK dout0_14 Vdout0_14ck105 = 0 time = 2120
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=2120.1n

* CHECK dout0_15 Vdout0_15ck105 = 1.8 time = 2120
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=2120.1n

* CHECK dout0_16 Vdout0_16ck105 = 1.8 time = 2120
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=2120.1n

* CHECK dout0_17 Vdout0_17ck105 = 0 time = 2120
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=2120.1n

* CHECK dout0_18 Vdout0_18ck105 = 0 time = 2120
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=2120.1n

* CHECK dout0_19 Vdout0_19ck105 = 0 time = 2120
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=2120.1n

* CHECK dout0_20 Vdout0_20ck105 = 1.8 time = 2120
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=2120.1n

* CHECK dout0_21 Vdout0_21ck105 = 1.8 time = 2120
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=2120.1n

* CHECK dout0_22 Vdout0_22ck105 = 1.8 time = 2120
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=2120.1n

* CHECK dout0_23 Vdout0_23ck105 = 0 time = 2120
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=2120.1n

* CHECK dout0_24 Vdout0_24ck105 = 1.8 time = 2120
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=2120.1n

* CHECK dout0_25 Vdout0_25ck105 = 0 time = 2120
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=2120.1n

* CHECK dout0_26 Vdout0_26ck105 = 0 time = 2120
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=2120.1n

* CHECK dout0_27 Vdout0_27ck105 = 0 time = 2120
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=2120.1n

* CHECK dout0_28 Vdout0_28ck105 = 1.8 time = 2120
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=2120.1n

* CHECK dout0_29 Vdout0_29ck105 = 0 time = 2120
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=2120.1n

* CHECK dout0_30 Vdout0_30ck105 = 1.8 time = 2120
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=2120.1n

* CHECK dout0_31 Vdout0_31ck105 = 1.8 time = 2120
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=2120.1n

* CHECK dout0_0 Vdout0_0ck107 = 1.8 time = 2160
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=2160.1n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 2160
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=2160.1n

* CHECK dout0_2 Vdout0_2ck107 = 1.8 time = 2160
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=2160.1n

* CHECK dout0_3 Vdout0_3ck107 = 0 time = 2160
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=2160.1n

* CHECK dout0_4 Vdout0_4ck107 = 1.8 time = 2160
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=2160.1n

* CHECK dout0_5 Vdout0_5ck107 = 1.8 time = 2160
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=2160.1n

* CHECK dout0_6 Vdout0_6ck107 = 0 time = 2160
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=2160.1n

* CHECK dout0_7 Vdout0_7ck107 = 0 time = 2160
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=2160.1n

* CHECK dout0_8 Vdout0_8ck107 = 1.8 time = 2160
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=2160.1n

* CHECK dout0_9 Vdout0_9ck107 = 0 time = 2160
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=2160.1n

* CHECK dout0_10 Vdout0_10ck107 = 1.8 time = 2160
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=2160.1n

* CHECK dout0_11 Vdout0_11ck107 = 0 time = 2160
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=2160.1n

* CHECK dout0_12 Vdout0_12ck107 = 0 time = 2160
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=2160.1n

* CHECK dout0_13 Vdout0_13ck107 = 1.8 time = 2160
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=2160.1n

* CHECK dout0_14 Vdout0_14ck107 = 1.8 time = 2160
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=2160.1n

* CHECK dout0_15 Vdout0_15ck107 = 1.8 time = 2160
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=2160.1n

* CHECK dout0_16 Vdout0_16ck107 = 0 time = 2160
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=2160.1n

* CHECK dout0_17 Vdout0_17ck107 = 1.8 time = 2160
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=2160.1n

* CHECK dout0_18 Vdout0_18ck107 = 0 time = 2160
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=2160.1n

* CHECK dout0_19 Vdout0_19ck107 = 0 time = 2160
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=2160.1n

* CHECK dout0_20 Vdout0_20ck107 = 1.8 time = 2160
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=2160.1n

* CHECK dout0_21 Vdout0_21ck107 = 1.8 time = 2160
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=2160.1n

* CHECK dout0_22 Vdout0_22ck107 = 1.8 time = 2160
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=2160.1n

* CHECK dout0_23 Vdout0_23ck107 = 1.8 time = 2160
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=2160.1n

* CHECK dout0_24 Vdout0_24ck107 = 1.8 time = 2160
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=2160.1n

* CHECK dout0_25 Vdout0_25ck107 = 0 time = 2160
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=2160.1n

* CHECK dout0_26 Vdout0_26ck107 = 1.8 time = 2160
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=2160.1n

* CHECK dout0_27 Vdout0_27ck107 = 1.8 time = 2160
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=2160.1n

* CHECK dout0_28 Vdout0_28ck107 = 1.8 time = 2160
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=2160.1n

* CHECK dout0_29 Vdout0_29ck107 = 1.8 time = 2160
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=2160.1n

* CHECK dout0_30 Vdout0_30ck107 = 1.8 time = 2160
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=2160.1n

* CHECK dout0_31 Vdout0_31ck107 = 1.8 time = 2160
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=2160.1n

* CHECK dout0_0 Vdout0_0ck111 = 0 time = 2240
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=2240.1n

* CHECK dout0_1 Vdout0_1ck111 = 1.8 time = 2240
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=2240.1n

* CHECK dout0_2 Vdout0_2ck111 = 0 time = 2240
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=2240.1n

* CHECK dout0_3 Vdout0_3ck111 = 0 time = 2240
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=2240.1n

* CHECK dout0_4 Vdout0_4ck111 = 1.8 time = 2240
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=2240.1n

* CHECK dout0_5 Vdout0_5ck111 = 0 time = 2240
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=2240.1n

* CHECK dout0_6 Vdout0_6ck111 = 0 time = 2240
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=2240.1n

* CHECK dout0_7 Vdout0_7ck111 = 1.8 time = 2240
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=2240.1n

* CHECK dout0_8 Vdout0_8ck111 = 1.8 time = 2240
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=2240.1n

* CHECK dout0_9 Vdout0_9ck111 = 1.8 time = 2240
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=2240.1n

* CHECK dout0_10 Vdout0_10ck111 = 1.8 time = 2240
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=2240.1n

* CHECK dout0_11 Vdout0_11ck111 = 0 time = 2240
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=2240.1n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 2240
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=2240.1n

* CHECK dout0_13 Vdout0_13ck111 = 1.8 time = 2240
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=2240.1n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 2240
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=2240.1n

* CHECK dout0_15 Vdout0_15ck111 = 0 time = 2240
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=2240.1n

* CHECK dout0_16 Vdout0_16ck111 = 0 time = 2240
.meas tran vdout0_16ck111 FIND v(dout0_16) AT=2240.1n

* CHECK dout0_17 Vdout0_17ck111 = 0 time = 2240
.meas tran vdout0_17ck111 FIND v(dout0_17) AT=2240.1n

* CHECK dout0_18 Vdout0_18ck111 = 0 time = 2240
.meas tran vdout0_18ck111 FIND v(dout0_18) AT=2240.1n

* CHECK dout0_19 Vdout0_19ck111 = 1.8 time = 2240
.meas tran vdout0_19ck111 FIND v(dout0_19) AT=2240.1n

* CHECK dout0_20 Vdout0_20ck111 = 0 time = 2240
.meas tran vdout0_20ck111 FIND v(dout0_20) AT=2240.1n

* CHECK dout0_21 Vdout0_21ck111 = 1.8 time = 2240
.meas tran vdout0_21ck111 FIND v(dout0_21) AT=2240.1n

* CHECK dout0_22 Vdout0_22ck111 = 0 time = 2240
.meas tran vdout0_22ck111 FIND v(dout0_22) AT=2240.1n

* CHECK dout0_23 Vdout0_23ck111 = 1.8 time = 2240
.meas tran vdout0_23ck111 FIND v(dout0_23) AT=2240.1n

* CHECK dout0_24 Vdout0_24ck111 = 1.8 time = 2240
.meas tran vdout0_24ck111 FIND v(dout0_24) AT=2240.1n

* CHECK dout0_25 Vdout0_25ck111 = 1.8 time = 2240
.meas tran vdout0_25ck111 FIND v(dout0_25) AT=2240.1n

* CHECK dout0_26 Vdout0_26ck111 = 1.8 time = 2240
.meas tran vdout0_26ck111 FIND v(dout0_26) AT=2240.1n

* CHECK dout0_27 Vdout0_27ck111 = 0 time = 2240
.meas tran vdout0_27ck111 FIND v(dout0_27) AT=2240.1n

* CHECK dout0_28 Vdout0_28ck111 = 0 time = 2240
.meas tran vdout0_28ck111 FIND v(dout0_28) AT=2240.1n

* CHECK dout0_29 Vdout0_29ck111 = 1.8 time = 2240
.meas tran vdout0_29ck111 FIND v(dout0_29) AT=2240.1n

* CHECK dout0_30 Vdout0_30ck111 = 1.8 time = 2240
.meas tran vdout0_30ck111 FIND v(dout0_30) AT=2240.1n

* CHECK dout0_31 Vdout0_31ck111 = 0 time = 2240
.meas tran vdout0_31ck111 FIND v(dout0_31) AT=2240.1n

* CHECK dout0_0 Vdout0_0ck112 = 0 time = 2260
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=2260.1n

* CHECK dout0_1 Vdout0_1ck112 = 1.8 time = 2260
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=2260.1n

* CHECK dout0_2 Vdout0_2ck112 = 1.8 time = 2260
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=2260.1n

* CHECK dout0_3 Vdout0_3ck112 = 1.8 time = 2260
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=2260.1n

* CHECK dout0_4 Vdout0_4ck112 = 1.8 time = 2260
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=2260.1n

* CHECK dout0_5 Vdout0_5ck112 = 1.8 time = 2260
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=2260.1n

* CHECK dout0_6 Vdout0_6ck112 = 1.8 time = 2260
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=2260.1n

* CHECK dout0_7 Vdout0_7ck112 = 1.8 time = 2260
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=2260.1n

* CHECK dout0_8 Vdout0_8ck112 = 0 time = 2260
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=2260.1n

* CHECK dout0_9 Vdout0_9ck112 = 0 time = 2260
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=2260.1n

* CHECK dout0_10 Vdout0_10ck112 = 0 time = 2260
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=2260.1n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 2260
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=2260.1n

* CHECK dout0_12 Vdout0_12ck112 = 1.8 time = 2260
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=2260.1n

* CHECK dout0_13 Vdout0_13ck112 = 0 time = 2260
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=2260.1n

* CHECK dout0_14 Vdout0_14ck112 = 1.8 time = 2260
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=2260.1n

* CHECK dout0_15 Vdout0_15ck112 = 1.8 time = 2260
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=2260.1n

* CHECK dout0_16 Vdout0_16ck112 = 0 time = 2260
.meas tran vdout0_16ck112 FIND v(dout0_16) AT=2260.1n

* CHECK dout0_17 Vdout0_17ck112 = 0 time = 2260
.meas tran vdout0_17ck112 FIND v(dout0_17) AT=2260.1n

* CHECK dout0_18 Vdout0_18ck112 = 0 time = 2260
.meas tran vdout0_18ck112 FIND v(dout0_18) AT=2260.1n

* CHECK dout0_19 Vdout0_19ck112 = 0 time = 2260
.meas tran vdout0_19ck112 FIND v(dout0_19) AT=2260.1n

* CHECK dout0_20 Vdout0_20ck112 = 0 time = 2260
.meas tran vdout0_20ck112 FIND v(dout0_20) AT=2260.1n

* CHECK dout0_21 Vdout0_21ck112 = 1.8 time = 2260
.meas tran vdout0_21ck112 FIND v(dout0_21) AT=2260.1n

* CHECK dout0_22 Vdout0_22ck112 = 0 time = 2260
.meas tran vdout0_22ck112 FIND v(dout0_22) AT=2260.1n

* CHECK dout0_23 Vdout0_23ck112 = 1.8 time = 2260
.meas tran vdout0_23ck112 FIND v(dout0_23) AT=2260.1n

* CHECK dout0_24 Vdout0_24ck112 = 1.8 time = 2260
.meas tran vdout0_24ck112 FIND v(dout0_24) AT=2260.1n

* CHECK dout0_25 Vdout0_25ck112 = 1.8 time = 2260
.meas tran vdout0_25ck112 FIND v(dout0_25) AT=2260.1n

* CHECK dout0_26 Vdout0_26ck112 = 0 time = 2260
.meas tran vdout0_26ck112 FIND v(dout0_26) AT=2260.1n

* CHECK dout0_27 Vdout0_27ck112 = 1.8 time = 2260
.meas tran vdout0_27ck112 FIND v(dout0_27) AT=2260.1n

* CHECK dout0_28 Vdout0_28ck112 = 1.8 time = 2260
.meas tran vdout0_28ck112 FIND v(dout0_28) AT=2260.1n

* CHECK dout0_29 Vdout0_29ck112 = 1.8 time = 2260
.meas tran vdout0_29ck112 FIND v(dout0_29) AT=2260.1n

* CHECK dout0_30 Vdout0_30ck112 = 1.8 time = 2260
.meas tran vdout0_30ck112 FIND v(dout0_30) AT=2260.1n

* CHECK dout0_31 Vdout0_31ck112 = 0 time = 2260
.meas tran vdout0_31ck112 FIND v(dout0_31) AT=2260.1n

* CHECK dout0_0 Vdout0_0ck113 = 0 time = 2280
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=2280.1n

* CHECK dout0_1 Vdout0_1ck113 = 1.8 time = 2280
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=2280.1n

* CHECK dout0_2 Vdout0_2ck113 = 0 time = 2280
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=2280.1n

* CHECK dout0_3 Vdout0_3ck113 = 1.8 time = 2280
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=2280.1n

* CHECK dout0_4 Vdout0_4ck113 = 1.8 time = 2280
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=2280.1n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 2280
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=2280.1n

* CHECK dout0_6 Vdout0_6ck113 = 0 time = 2280
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=2280.1n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 2280
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=2280.1n

* CHECK dout0_8 Vdout0_8ck113 = 0 time = 2280
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=2280.1n

* CHECK dout0_9 Vdout0_9ck113 = 1.8 time = 2280
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=2280.1n

* CHECK dout0_10 Vdout0_10ck113 = 1.8 time = 2280
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=2280.1n

* CHECK dout0_11 Vdout0_11ck113 = 1.8 time = 2280
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=2280.1n

* CHECK dout0_12 Vdout0_12ck113 = 1.8 time = 2280
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=2280.1n

* CHECK dout0_13 Vdout0_13ck113 = 1.8 time = 2280
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=2280.1n

* CHECK dout0_14 Vdout0_14ck113 = 1.8 time = 2280
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=2280.1n

* CHECK dout0_15 Vdout0_15ck113 = 1.8 time = 2280
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=2280.1n

* CHECK dout0_16 Vdout0_16ck113 = 1.8 time = 2280
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=2280.1n

* CHECK dout0_17 Vdout0_17ck113 = 1.8 time = 2280
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=2280.1n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 2280
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=2280.1n

* CHECK dout0_19 Vdout0_19ck113 = 1.8 time = 2280
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=2280.1n

* CHECK dout0_20 Vdout0_20ck113 = 1.8 time = 2280
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=2280.1n

* CHECK dout0_21 Vdout0_21ck113 = 1.8 time = 2280
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=2280.1n

* CHECK dout0_22 Vdout0_22ck113 = 0 time = 2280
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=2280.1n

* CHECK dout0_23 Vdout0_23ck113 = 0 time = 2280
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=2280.1n

* CHECK dout0_24 Vdout0_24ck113 = 1.8 time = 2280
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=2280.1n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 2280
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=2280.1n

* CHECK dout0_26 Vdout0_26ck113 = 1.8 time = 2280
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=2280.1n

* CHECK dout0_27 Vdout0_27ck113 = 0 time = 2280
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=2280.1n

* CHECK dout0_28 Vdout0_28ck113 = 0 time = 2280
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=2280.1n

* CHECK dout0_29 Vdout0_29ck113 = 0 time = 2280
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=2280.1n

* CHECK dout0_30 Vdout0_30ck113 = 1.8 time = 2280
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=2280.1n

* CHECK dout0_31 Vdout0_31ck113 = 0 time = 2280
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=2280.1n

* CHECK dout0_0 Vdout0_0ck116 = 0 time = 2340
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=2340.1n

* CHECK dout0_1 Vdout0_1ck116 = 0 time = 2340
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=2340.1n

* CHECK dout0_2 Vdout0_2ck116 = 1.8 time = 2340
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=2340.1n

* CHECK dout0_3 Vdout0_3ck116 = 1.8 time = 2340
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=2340.1n

* CHECK dout0_4 Vdout0_4ck116 = 0 time = 2340
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=2340.1n

* CHECK dout0_5 Vdout0_5ck116 = 0 time = 2340
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=2340.1n

* CHECK dout0_6 Vdout0_6ck116 = 1.8 time = 2340
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=2340.1n

* CHECK dout0_7 Vdout0_7ck116 = 1.8 time = 2340
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=2340.1n

* CHECK dout0_8 Vdout0_8ck116 = 0 time = 2340
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=2340.1n

* CHECK dout0_9 Vdout0_9ck116 = 1.8 time = 2340
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=2340.1n

* CHECK dout0_10 Vdout0_10ck116 = 1.8 time = 2340
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=2340.1n

* CHECK dout0_11 Vdout0_11ck116 = 1.8 time = 2340
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=2340.1n

* CHECK dout0_12 Vdout0_12ck116 = 1.8 time = 2340
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=2340.1n

* CHECK dout0_13 Vdout0_13ck116 = 1.8 time = 2340
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=2340.1n

* CHECK dout0_14 Vdout0_14ck116 = 1.8 time = 2340
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=2340.1n

* CHECK dout0_15 Vdout0_15ck116 = 1.8 time = 2340
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=2340.1n

* CHECK dout0_16 Vdout0_16ck116 = 1.8 time = 2340
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=2340.1n

* CHECK dout0_17 Vdout0_17ck116 = 1.8 time = 2340
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=2340.1n

* CHECK dout0_18 Vdout0_18ck116 = 1.8 time = 2340
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=2340.1n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 2340
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=2340.1n

* CHECK dout0_20 Vdout0_20ck116 = 1.8 time = 2340
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=2340.1n

* CHECK dout0_21 Vdout0_21ck116 = 1.8 time = 2340
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=2340.1n

* CHECK dout0_22 Vdout0_22ck116 = 1.8 time = 2340
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=2340.1n

* CHECK dout0_23 Vdout0_23ck116 = 0 time = 2340
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=2340.1n

* CHECK dout0_24 Vdout0_24ck116 = 0 time = 2340
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=2340.1n

* CHECK dout0_25 Vdout0_25ck116 = 0 time = 2340
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=2340.1n

* CHECK dout0_26 Vdout0_26ck116 = 0 time = 2340
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=2340.1n

* CHECK dout0_27 Vdout0_27ck116 = 1.8 time = 2340
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=2340.1n

* CHECK dout0_28 Vdout0_28ck116 = 0 time = 2340
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=2340.1n

* CHECK dout0_29 Vdout0_29ck116 = 0 time = 2340
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=2340.1n

* CHECK dout0_30 Vdout0_30ck116 = 1.8 time = 2340
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=2340.1n

* CHECK dout0_31 Vdout0_31ck116 = 0 time = 2340
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=2340.1n

* CHECK dout0_0 Vdout0_0ck117 = 0 time = 2360
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=2360.1n

* CHECK dout0_1 Vdout0_1ck117 = 0 time = 2360
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=2360.1n

* CHECK dout0_2 Vdout0_2ck117 = 1.8 time = 2360
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=2360.1n

* CHECK dout0_3 Vdout0_3ck117 = 1.8 time = 2360
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=2360.1n

* CHECK dout0_4 Vdout0_4ck117 = 0 time = 2360
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=2360.1n

* CHECK dout0_5 Vdout0_5ck117 = 0 time = 2360
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=2360.1n

* CHECK dout0_6 Vdout0_6ck117 = 1.8 time = 2360
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=2360.1n

* CHECK dout0_7 Vdout0_7ck117 = 1.8 time = 2360
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=2360.1n

* CHECK dout0_8 Vdout0_8ck117 = 0 time = 2360
.meas tran vdout0_8ck117 FIND v(dout0_8) AT=2360.1n

* CHECK dout0_9 Vdout0_9ck117 = 1.8 time = 2360
.meas tran vdout0_9ck117 FIND v(dout0_9) AT=2360.1n

* CHECK dout0_10 Vdout0_10ck117 = 1.8 time = 2360
.meas tran vdout0_10ck117 FIND v(dout0_10) AT=2360.1n

* CHECK dout0_11 Vdout0_11ck117 = 1.8 time = 2360
.meas tran vdout0_11ck117 FIND v(dout0_11) AT=2360.1n

* CHECK dout0_12 Vdout0_12ck117 = 1.8 time = 2360
.meas tran vdout0_12ck117 FIND v(dout0_12) AT=2360.1n

* CHECK dout0_13 Vdout0_13ck117 = 1.8 time = 2360
.meas tran vdout0_13ck117 FIND v(dout0_13) AT=2360.1n

* CHECK dout0_14 Vdout0_14ck117 = 1.8 time = 2360
.meas tran vdout0_14ck117 FIND v(dout0_14) AT=2360.1n

* CHECK dout0_15 Vdout0_15ck117 = 1.8 time = 2360
.meas tran vdout0_15ck117 FIND v(dout0_15) AT=2360.1n

* CHECK dout0_16 Vdout0_16ck117 = 1.8 time = 2360
.meas tran vdout0_16ck117 FIND v(dout0_16) AT=2360.1n

* CHECK dout0_17 Vdout0_17ck117 = 1.8 time = 2360
.meas tran vdout0_17ck117 FIND v(dout0_17) AT=2360.1n

* CHECK dout0_18 Vdout0_18ck117 = 1.8 time = 2360
.meas tran vdout0_18ck117 FIND v(dout0_18) AT=2360.1n

* CHECK dout0_19 Vdout0_19ck117 = 0 time = 2360
.meas tran vdout0_19ck117 FIND v(dout0_19) AT=2360.1n

* CHECK dout0_20 Vdout0_20ck117 = 1.8 time = 2360
.meas tran vdout0_20ck117 FIND v(dout0_20) AT=2360.1n

* CHECK dout0_21 Vdout0_21ck117 = 1.8 time = 2360
.meas tran vdout0_21ck117 FIND v(dout0_21) AT=2360.1n

* CHECK dout0_22 Vdout0_22ck117 = 1.8 time = 2360
.meas tran vdout0_22ck117 FIND v(dout0_22) AT=2360.1n

* CHECK dout0_23 Vdout0_23ck117 = 0 time = 2360
.meas tran vdout0_23ck117 FIND v(dout0_23) AT=2360.1n

* CHECK dout0_24 Vdout0_24ck117 = 0 time = 2360
.meas tran vdout0_24ck117 FIND v(dout0_24) AT=2360.1n

* CHECK dout0_25 Vdout0_25ck117 = 0 time = 2360
.meas tran vdout0_25ck117 FIND v(dout0_25) AT=2360.1n

* CHECK dout0_26 Vdout0_26ck117 = 0 time = 2360
.meas tran vdout0_26ck117 FIND v(dout0_26) AT=2360.1n

* CHECK dout0_27 Vdout0_27ck117 = 1.8 time = 2360
.meas tran vdout0_27ck117 FIND v(dout0_27) AT=2360.1n

* CHECK dout0_28 Vdout0_28ck117 = 0 time = 2360
.meas tran vdout0_28ck117 FIND v(dout0_28) AT=2360.1n

* CHECK dout0_29 Vdout0_29ck117 = 0 time = 2360
.meas tran vdout0_29ck117 FIND v(dout0_29) AT=2360.1n

* CHECK dout0_30 Vdout0_30ck117 = 1.8 time = 2360
.meas tran vdout0_30ck117 FIND v(dout0_30) AT=2360.1n

* CHECK dout0_31 Vdout0_31ck117 = 0 time = 2360
.meas tran vdout0_31ck117 FIND v(dout0_31) AT=2360.1n

* CHECK dout0_0 Vdout0_0ck119 = 0 time = 2400
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=2400.1n

* CHECK dout0_1 Vdout0_1ck119 = 0 time = 2400
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=2400.1n

* CHECK dout0_2 Vdout0_2ck119 = 1.8 time = 2400
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=2400.1n

* CHECK dout0_3 Vdout0_3ck119 = 1.8 time = 2400
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=2400.1n

* CHECK dout0_4 Vdout0_4ck119 = 1.8 time = 2400
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=2400.1n

* CHECK dout0_5 Vdout0_5ck119 = 1.8 time = 2400
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=2400.1n

* CHECK dout0_6 Vdout0_6ck119 = 0 time = 2400
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=2400.1n

* CHECK dout0_7 Vdout0_7ck119 = 0 time = 2400
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=2400.1n

* CHECK dout0_8 Vdout0_8ck119 = 0 time = 2400
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=2400.1n

* CHECK dout0_9 Vdout0_9ck119 = 1.8 time = 2400
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=2400.1n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 2400
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=2400.1n

* CHECK dout0_11 Vdout0_11ck119 = 0 time = 2400
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=2400.1n

* CHECK dout0_12 Vdout0_12ck119 = 1.8 time = 2400
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=2400.1n

* CHECK dout0_13 Vdout0_13ck119 = 1.8 time = 2400
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=2400.1n

* CHECK dout0_14 Vdout0_14ck119 = 1.8 time = 2400
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=2400.1n

* CHECK dout0_15 Vdout0_15ck119 = 0 time = 2400
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=2400.1n

* CHECK dout0_16 Vdout0_16ck119 = 1.8 time = 2400
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=2400.1n

* CHECK dout0_17 Vdout0_17ck119 = 0 time = 2400
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=2400.1n

* CHECK dout0_18 Vdout0_18ck119 = 1.8 time = 2400
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=2400.1n

* CHECK dout0_19 Vdout0_19ck119 = 0 time = 2400
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=2400.1n

* CHECK dout0_20 Vdout0_20ck119 = 0 time = 2400
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=2400.1n

* CHECK dout0_21 Vdout0_21ck119 = 0 time = 2400
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=2400.1n

* CHECK dout0_22 Vdout0_22ck119 = 0 time = 2400
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=2400.1n

* CHECK dout0_23 Vdout0_23ck119 = 1.8 time = 2400
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=2400.1n

* CHECK dout0_24 Vdout0_24ck119 = 1.8 time = 2400
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=2400.1n

* CHECK dout0_25 Vdout0_25ck119 = 1.8 time = 2400
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=2400.1n

* CHECK dout0_26 Vdout0_26ck119 = 1.8 time = 2400
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=2400.1n

* CHECK dout0_27 Vdout0_27ck119 = 1.8 time = 2400
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=2400.1n

* CHECK dout0_28 Vdout0_28ck119 = 0 time = 2400
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=2400.1n

* CHECK dout0_29 Vdout0_29ck119 = 0 time = 2400
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=2400.1n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 2400
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=2400.1n

* CHECK dout0_31 Vdout0_31ck119 = 1.8 time = 2400
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=2400.1n

* CHECK dout0_0 Vdout0_0ck122 = 0 time = 2460
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=2460.1n

* CHECK dout0_1 Vdout0_1ck122 = 0 time = 2460
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=2460.1n

* CHECK dout0_2 Vdout0_2ck122 = 1.8 time = 2460
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=2460.1n

* CHECK dout0_3 Vdout0_3ck122 = 1.8 time = 2460
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=2460.1n

* CHECK dout0_4 Vdout0_4ck122 = 1.8 time = 2460
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=2460.1n

* CHECK dout0_5 Vdout0_5ck122 = 1.8 time = 2460
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=2460.1n

* CHECK dout0_6 Vdout0_6ck122 = 0 time = 2460
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=2460.1n

* CHECK dout0_7 Vdout0_7ck122 = 0 time = 2460
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=2460.1n

* CHECK dout0_8 Vdout0_8ck122 = 0 time = 2460
.meas tran vdout0_8ck122 FIND v(dout0_8) AT=2460.1n

* CHECK dout0_9 Vdout0_9ck122 = 1.8 time = 2460
.meas tran vdout0_9ck122 FIND v(dout0_9) AT=2460.1n

* CHECK dout0_10 Vdout0_10ck122 = 0 time = 2460
.meas tran vdout0_10ck122 FIND v(dout0_10) AT=2460.1n

* CHECK dout0_11 Vdout0_11ck122 = 0 time = 2460
.meas tran vdout0_11ck122 FIND v(dout0_11) AT=2460.1n

* CHECK dout0_12 Vdout0_12ck122 = 1.8 time = 2460
.meas tran vdout0_12ck122 FIND v(dout0_12) AT=2460.1n

* CHECK dout0_13 Vdout0_13ck122 = 1.8 time = 2460
.meas tran vdout0_13ck122 FIND v(dout0_13) AT=2460.1n

* CHECK dout0_14 Vdout0_14ck122 = 1.8 time = 2460
.meas tran vdout0_14ck122 FIND v(dout0_14) AT=2460.1n

* CHECK dout0_15 Vdout0_15ck122 = 0 time = 2460
.meas tran vdout0_15ck122 FIND v(dout0_15) AT=2460.1n

* CHECK dout0_16 Vdout0_16ck122 = 1.8 time = 2460
.meas tran vdout0_16ck122 FIND v(dout0_16) AT=2460.1n

* CHECK dout0_17 Vdout0_17ck122 = 0 time = 2460
.meas tran vdout0_17ck122 FIND v(dout0_17) AT=2460.1n

* CHECK dout0_18 Vdout0_18ck122 = 1.8 time = 2460
.meas tran vdout0_18ck122 FIND v(dout0_18) AT=2460.1n

* CHECK dout0_19 Vdout0_19ck122 = 0 time = 2460
.meas tran vdout0_19ck122 FIND v(dout0_19) AT=2460.1n

* CHECK dout0_20 Vdout0_20ck122 = 0 time = 2460
.meas tran vdout0_20ck122 FIND v(dout0_20) AT=2460.1n

* CHECK dout0_21 Vdout0_21ck122 = 0 time = 2460
.meas tran vdout0_21ck122 FIND v(dout0_21) AT=2460.1n

* CHECK dout0_22 Vdout0_22ck122 = 0 time = 2460
.meas tran vdout0_22ck122 FIND v(dout0_22) AT=2460.1n

* CHECK dout0_23 Vdout0_23ck122 = 1.8 time = 2460
.meas tran vdout0_23ck122 FIND v(dout0_23) AT=2460.1n

* CHECK dout0_24 Vdout0_24ck122 = 1.8 time = 2460
.meas tran vdout0_24ck122 FIND v(dout0_24) AT=2460.1n

* CHECK dout0_25 Vdout0_25ck122 = 1.8 time = 2460
.meas tran vdout0_25ck122 FIND v(dout0_25) AT=2460.1n

* CHECK dout0_26 Vdout0_26ck122 = 1.8 time = 2460
.meas tran vdout0_26ck122 FIND v(dout0_26) AT=2460.1n

* CHECK dout0_27 Vdout0_27ck122 = 1.8 time = 2460
.meas tran vdout0_27ck122 FIND v(dout0_27) AT=2460.1n

* CHECK dout0_28 Vdout0_28ck122 = 0 time = 2460
.meas tran vdout0_28ck122 FIND v(dout0_28) AT=2460.1n

* CHECK dout0_29 Vdout0_29ck122 = 0 time = 2460
.meas tran vdout0_29ck122 FIND v(dout0_29) AT=2460.1n

* CHECK dout0_30 Vdout0_30ck122 = 0 time = 2460
.meas tran vdout0_30ck122 FIND v(dout0_30) AT=2460.1n

* CHECK dout0_31 Vdout0_31ck122 = 1.8 time = 2460
.meas tran vdout0_31ck122 FIND v(dout0_31) AT=2460.1n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 2540
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=2540.1n

* CHECK dout0_1 Vdout0_1ck126 = 1.8 time = 2540
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=2540.1n

* CHECK dout0_2 Vdout0_2ck126 = 0 time = 2540
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=2540.1n

* CHECK dout0_3 Vdout0_3ck126 = 1.8 time = 2540
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=2540.1n

* CHECK dout0_4 Vdout0_4ck126 = 1.8 time = 2540
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=2540.1n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 2540
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=2540.1n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 2540
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=2540.1n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 2540
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=2540.1n

* CHECK dout0_8 Vdout0_8ck126 = 0 time = 2540
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=2540.1n

* CHECK dout0_9 Vdout0_9ck126 = 1.8 time = 2540
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=2540.1n

* CHECK dout0_10 Vdout0_10ck126 = 1.8 time = 2540
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=2540.1n

* CHECK dout0_11 Vdout0_11ck126 = 1.8 time = 2540
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=2540.1n

* CHECK dout0_12 Vdout0_12ck126 = 1.8 time = 2540
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=2540.1n

* CHECK dout0_13 Vdout0_13ck126 = 1.8 time = 2540
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=2540.1n

* CHECK dout0_14 Vdout0_14ck126 = 1.8 time = 2540
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=2540.1n

* CHECK dout0_15 Vdout0_15ck126 = 1.8 time = 2540
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=2540.1n

* CHECK dout0_16 Vdout0_16ck126 = 1.8 time = 2540
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=2540.1n

* CHECK dout0_17 Vdout0_17ck126 = 1.8 time = 2540
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=2540.1n

* CHECK dout0_18 Vdout0_18ck126 = 0 time = 2540
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=2540.1n

* CHECK dout0_19 Vdout0_19ck126 = 1.8 time = 2540
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=2540.1n

* CHECK dout0_20 Vdout0_20ck126 = 1.8 time = 2540
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=2540.1n

* CHECK dout0_21 Vdout0_21ck126 = 1.8 time = 2540
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=2540.1n

* CHECK dout0_22 Vdout0_22ck126 = 0 time = 2540
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=2540.1n

* CHECK dout0_23 Vdout0_23ck126 = 0 time = 2540
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=2540.1n

* CHECK dout0_24 Vdout0_24ck126 = 1.8 time = 2540
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=2540.1n

* CHECK dout0_25 Vdout0_25ck126 = 0 time = 2540
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=2540.1n

* CHECK dout0_26 Vdout0_26ck126 = 1.8 time = 2540
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=2540.1n

* CHECK dout0_27 Vdout0_27ck126 = 0 time = 2540
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=2540.1n

* CHECK dout0_28 Vdout0_28ck126 = 0 time = 2540
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=2540.1n

* CHECK dout0_29 Vdout0_29ck126 = 0 time = 2540
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=2540.1n

* CHECK dout0_30 Vdout0_30ck126 = 1.8 time = 2540
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=2540.1n

* CHECK dout0_31 Vdout0_31ck126 = 0 time = 2540
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=2540.1n

* CHECK dout0_0 Vdout0_0ck129 = 0 time = 2600
.meas tran vdout0_0ck129 FIND v(dout0_0) AT=2600.1n

* CHECK dout0_1 Vdout0_1ck129 = 1.8 time = 2600
.meas tran vdout0_1ck129 FIND v(dout0_1) AT=2600.1n

* CHECK dout0_2 Vdout0_2ck129 = 0 time = 2600
.meas tran vdout0_2ck129 FIND v(dout0_2) AT=2600.1n

* CHECK dout0_3 Vdout0_3ck129 = 1.8 time = 2600
.meas tran vdout0_3ck129 FIND v(dout0_3) AT=2600.1n

* CHECK dout0_4 Vdout0_4ck129 = 1.8 time = 2600
.meas tran vdout0_4ck129 FIND v(dout0_4) AT=2600.1n

* CHECK dout0_5 Vdout0_5ck129 = 0 time = 2600
.meas tran vdout0_5ck129 FIND v(dout0_5) AT=2600.1n

* CHECK dout0_6 Vdout0_6ck129 = 0 time = 2600
.meas tran vdout0_6ck129 FIND v(dout0_6) AT=2600.1n

* CHECK dout0_7 Vdout0_7ck129 = 0 time = 2600
.meas tran vdout0_7ck129 FIND v(dout0_7) AT=2600.1n

* CHECK dout0_8 Vdout0_8ck129 = 0 time = 2600
.meas tran vdout0_8ck129 FIND v(dout0_8) AT=2600.1n

* CHECK dout0_9 Vdout0_9ck129 = 1.8 time = 2600
.meas tran vdout0_9ck129 FIND v(dout0_9) AT=2600.1n

* CHECK dout0_10 Vdout0_10ck129 = 1.8 time = 2600
.meas tran vdout0_10ck129 FIND v(dout0_10) AT=2600.1n

* CHECK dout0_11 Vdout0_11ck129 = 1.8 time = 2600
.meas tran vdout0_11ck129 FIND v(dout0_11) AT=2600.1n

* CHECK dout0_12 Vdout0_12ck129 = 1.8 time = 2600
.meas tran vdout0_12ck129 FIND v(dout0_12) AT=2600.1n

* CHECK dout0_13 Vdout0_13ck129 = 1.8 time = 2600
.meas tran vdout0_13ck129 FIND v(dout0_13) AT=2600.1n

* CHECK dout0_14 Vdout0_14ck129 = 1.8 time = 2600
.meas tran vdout0_14ck129 FIND v(dout0_14) AT=2600.1n

* CHECK dout0_15 Vdout0_15ck129 = 1.8 time = 2600
.meas tran vdout0_15ck129 FIND v(dout0_15) AT=2600.1n

* CHECK dout0_16 Vdout0_16ck129 = 1.8 time = 2600
.meas tran vdout0_16ck129 FIND v(dout0_16) AT=2600.1n

* CHECK dout0_17 Vdout0_17ck129 = 1.8 time = 2600
.meas tran vdout0_17ck129 FIND v(dout0_17) AT=2600.1n

* CHECK dout0_18 Vdout0_18ck129 = 0 time = 2600
.meas tran vdout0_18ck129 FIND v(dout0_18) AT=2600.1n

* CHECK dout0_19 Vdout0_19ck129 = 1.8 time = 2600
.meas tran vdout0_19ck129 FIND v(dout0_19) AT=2600.1n

* CHECK dout0_20 Vdout0_20ck129 = 1.8 time = 2600
.meas tran vdout0_20ck129 FIND v(dout0_20) AT=2600.1n

* CHECK dout0_21 Vdout0_21ck129 = 1.8 time = 2600
.meas tran vdout0_21ck129 FIND v(dout0_21) AT=2600.1n

* CHECK dout0_22 Vdout0_22ck129 = 0 time = 2600
.meas tran vdout0_22ck129 FIND v(dout0_22) AT=2600.1n

* CHECK dout0_23 Vdout0_23ck129 = 0 time = 2600
.meas tran vdout0_23ck129 FIND v(dout0_23) AT=2600.1n

* CHECK dout0_24 Vdout0_24ck129 = 1.8 time = 2600
.meas tran vdout0_24ck129 FIND v(dout0_24) AT=2600.1n

* CHECK dout0_25 Vdout0_25ck129 = 0 time = 2600
.meas tran vdout0_25ck129 FIND v(dout0_25) AT=2600.1n

* CHECK dout0_26 Vdout0_26ck129 = 1.8 time = 2600
.meas tran vdout0_26ck129 FIND v(dout0_26) AT=2600.1n

* CHECK dout0_27 Vdout0_27ck129 = 0 time = 2600
.meas tran vdout0_27ck129 FIND v(dout0_27) AT=2600.1n

* CHECK dout0_28 Vdout0_28ck129 = 0 time = 2600
.meas tran vdout0_28ck129 FIND v(dout0_28) AT=2600.1n

* CHECK dout0_29 Vdout0_29ck129 = 0 time = 2600
.meas tran vdout0_29ck129 FIND v(dout0_29) AT=2600.1n

* CHECK dout0_30 Vdout0_30ck129 = 1.8 time = 2600
.meas tran vdout0_30ck129 FIND v(dout0_30) AT=2600.1n

* CHECK dout0_31 Vdout0_31ck129 = 0 time = 2600
.meas tran vdout0_31ck129 FIND v(dout0_31) AT=2600.1n

* CHECK dout0_0 Vdout0_0ck134 = 1.8 time = 2700
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=2700.1n

* CHECK dout0_1 Vdout0_1ck134 = 1.8 time = 2700
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=2700.1n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 2700
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=2700.1n

* CHECK dout0_3 Vdout0_3ck134 = 1.8 time = 2700
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=2700.1n

* CHECK dout0_4 Vdout0_4ck134 = 0 time = 2700
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=2700.1n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 2700
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=2700.1n

* CHECK dout0_6 Vdout0_6ck134 = 1.8 time = 2700
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=2700.1n

* CHECK dout0_7 Vdout0_7ck134 = 1.8 time = 2700
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=2700.1n

* CHECK dout0_8 Vdout0_8ck134 = 1.8 time = 2700
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=2700.1n

* CHECK dout0_9 Vdout0_9ck134 = 0 time = 2700
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=2700.1n

* CHECK dout0_10 Vdout0_10ck134 = 0 time = 2700
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=2700.1n

* CHECK dout0_11 Vdout0_11ck134 = 0 time = 2700
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=2700.1n

* CHECK dout0_12 Vdout0_12ck134 = 1.8 time = 2700
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=2700.1n

* CHECK dout0_13 Vdout0_13ck134 = 0 time = 2700
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=2700.1n

* CHECK dout0_14 Vdout0_14ck134 = 1.8 time = 2700
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=2700.1n

* CHECK dout0_15 Vdout0_15ck134 = 0 time = 2700
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=2700.1n

* CHECK dout0_16 Vdout0_16ck134 = 0 time = 2700
.meas tran vdout0_16ck134 FIND v(dout0_16) AT=2700.1n

* CHECK dout0_17 Vdout0_17ck134 = 1.8 time = 2700
.meas tran vdout0_17ck134 FIND v(dout0_17) AT=2700.1n

* CHECK dout0_18 Vdout0_18ck134 = 0 time = 2700
.meas tran vdout0_18ck134 FIND v(dout0_18) AT=2700.1n

* CHECK dout0_19 Vdout0_19ck134 = 0 time = 2700
.meas tran vdout0_19ck134 FIND v(dout0_19) AT=2700.1n

* CHECK dout0_20 Vdout0_20ck134 = 1.8 time = 2700
.meas tran vdout0_20ck134 FIND v(dout0_20) AT=2700.1n

* CHECK dout0_21 Vdout0_21ck134 = 0 time = 2700
.meas tran vdout0_21ck134 FIND v(dout0_21) AT=2700.1n

* CHECK dout0_22 Vdout0_22ck134 = 1.8 time = 2700
.meas tran vdout0_22ck134 FIND v(dout0_22) AT=2700.1n

* CHECK dout0_23 Vdout0_23ck134 = 1.8 time = 2700
.meas tran vdout0_23ck134 FIND v(dout0_23) AT=2700.1n

* CHECK dout0_24 Vdout0_24ck134 = 0 time = 2700
.meas tran vdout0_24ck134 FIND v(dout0_24) AT=2700.1n

* CHECK dout0_25 Vdout0_25ck134 = 0 time = 2700
.meas tran vdout0_25ck134 FIND v(dout0_25) AT=2700.1n

* CHECK dout0_26 Vdout0_26ck134 = 1.8 time = 2700
.meas tran vdout0_26ck134 FIND v(dout0_26) AT=2700.1n

* CHECK dout0_27 Vdout0_27ck134 = 0 time = 2700
.meas tran vdout0_27ck134 FIND v(dout0_27) AT=2700.1n

* CHECK dout0_28 Vdout0_28ck134 = 0 time = 2700
.meas tran vdout0_28ck134 FIND v(dout0_28) AT=2700.1n

* CHECK dout0_29 Vdout0_29ck134 = 0 time = 2700
.meas tran vdout0_29ck134 FIND v(dout0_29) AT=2700.1n

* CHECK dout0_30 Vdout0_30ck134 = 1.8 time = 2700
.meas tran vdout0_30ck134 FIND v(dout0_30) AT=2700.1n

* CHECK dout0_31 Vdout0_31ck134 = 0 time = 2700
.meas tran vdout0_31ck134 FIND v(dout0_31) AT=2700.1n

* CHECK dout0_0 Vdout0_0ck136 = 0 time = 2740
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=2740.1n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 2740
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=2740.1n

* CHECK dout0_2 Vdout0_2ck136 = 1.8 time = 2740
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=2740.1n

* CHECK dout0_3 Vdout0_3ck136 = 1.8 time = 2740
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=2740.1n

* CHECK dout0_4 Vdout0_4ck136 = 1.8 time = 2740
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=2740.1n

* CHECK dout0_5 Vdout0_5ck136 = 1.8 time = 2740
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=2740.1n

* CHECK dout0_6 Vdout0_6ck136 = 0 time = 2740
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=2740.1n

* CHECK dout0_7 Vdout0_7ck136 = 0 time = 2740
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=2740.1n

* CHECK dout0_8 Vdout0_8ck136 = 0 time = 2740
.meas tran vdout0_8ck136 FIND v(dout0_8) AT=2740.1n

* CHECK dout0_9 Vdout0_9ck136 = 1.8 time = 2740
.meas tran vdout0_9ck136 FIND v(dout0_9) AT=2740.1n

* CHECK dout0_10 Vdout0_10ck136 = 0 time = 2740
.meas tran vdout0_10ck136 FIND v(dout0_10) AT=2740.1n

* CHECK dout0_11 Vdout0_11ck136 = 0 time = 2740
.meas tran vdout0_11ck136 FIND v(dout0_11) AT=2740.1n

* CHECK dout0_12 Vdout0_12ck136 = 1.8 time = 2740
.meas tran vdout0_12ck136 FIND v(dout0_12) AT=2740.1n

* CHECK dout0_13 Vdout0_13ck136 = 1.8 time = 2740
.meas tran vdout0_13ck136 FIND v(dout0_13) AT=2740.1n

* CHECK dout0_14 Vdout0_14ck136 = 1.8 time = 2740
.meas tran vdout0_14ck136 FIND v(dout0_14) AT=2740.1n

* CHECK dout0_15 Vdout0_15ck136 = 0 time = 2740
.meas tran vdout0_15ck136 FIND v(dout0_15) AT=2740.1n

* CHECK dout0_16 Vdout0_16ck136 = 1.8 time = 2740
.meas tran vdout0_16ck136 FIND v(dout0_16) AT=2740.1n

* CHECK dout0_17 Vdout0_17ck136 = 0 time = 2740
.meas tran vdout0_17ck136 FIND v(dout0_17) AT=2740.1n

* CHECK dout0_18 Vdout0_18ck136 = 1.8 time = 2740
.meas tran vdout0_18ck136 FIND v(dout0_18) AT=2740.1n

* CHECK dout0_19 Vdout0_19ck136 = 0 time = 2740
.meas tran vdout0_19ck136 FIND v(dout0_19) AT=2740.1n

* CHECK dout0_20 Vdout0_20ck136 = 0 time = 2740
.meas tran vdout0_20ck136 FIND v(dout0_20) AT=2740.1n

* CHECK dout0_21 Vdout0_21ck136 = 0 time = 2740
.meas tran vdout0_21ck136 FIND v(dout0_21) AT=2740.1n

* CHECK dout0_22 Vdout0_22ck136 = 0 time = 2740
.meas tran vdout0_22ck136 FIND v(dout0_22) AT=2740.1n

* CHECK dout0_23 Vdout0_23ck136 = 1.8 time = 2740
.meas tran vdout0_23ck136 FIND v(dout0_23) AT=2740.1n

* CHECK dout0_24 Vdout0_24ck136 = 1.8 time = 2740
.meas tran vdout0_24ck136 FIND v(dout0_24) AT=2740.1n

* CHECK dout0_25 Vdout0_25ck136 = 1.8 time = 2740
.meas tran vdout0_25ck136 FIND v(dout0_25) AT=2740.1n

* CHECK dout0_26 Vdout0_26ck136 = 1.8 time = 2740
.meas tran vdout0_26ck136 FIND v(dout0_26) AT=2740.1n

* CHECK dout0_27 Vdout0_27ck136 = 1.8 time = 2740
.meas tran vdout0_27ck136 FIND v(dout0_27) AT=2740.1n

* CHECK dout0_28 Vdout0_28ck136 = 0 time = 2740
.meas tran vdout0_28ck136 FIND v(dout0_28) AT=2740.1n

* CHECK dout0_29 Vdout0_29ck136 = 0 time = 2740
.meas tran vdout0_29ck136 FIND v(dout0_29) AT=2740.1n

* CHECK dout0_30 Vdout0_30ck136 = 0 time = 2740
.meas tran vdout0_30ck136 FIND v(dout0_30) AT=2740.1n

* CHECK dout0_31 Vdout0_31ck136 = 1.8 time = 2740
.meas tran vdout0_31ck136 FIND v(dout0_31) AT=2740.1n

* CHECK dout0_0 Vdout0_0ck137 = 1.8 time = 2760
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=2760.1n

* CHECK dout0_1 Vdout0_1ck137 = 1.8 time = 2760
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=2760.1n

* CHECK dout0_2 Vdout0_2ck137 = 0 time = 2760
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=2760.1n

* CHECK dout0_3 Vdout0_3ck137 = 1.8 time = 2760
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=2760.1n

* CHECK dout0_4 Vdout0_4ck137 = 0 time = 2760
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=2760.1n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 2760
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=2760.1n

* CHECK dout0_6 Vdout0_6ck137 = 1.8 time = 2760
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=2760.1n

* CHECK dout0_7 Vdout0_7ck137 = 1.8 time = 2760
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=2760.1n

* CHECK dout0_8 Vdout0_8ck137 = 1.8 time = 2760
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=2760.1n

* CHECK dout0_9 Vdout0_9ck137 = 0 time = 2760
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=2760.1n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 2760
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=2760.1n

* CHECK dout0_11 Vdout0_11ck137 = 0 time = 2760
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=2760.1n

* CHECK dout0_12 Vdout0_12ck137 = 1.8 time = 2760
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=2760.1n

* CHECK dout0_13 Vdout0_13ck137 = 0 time = 2760
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=2760.1n

* CHECK dout0_14 Vdout0_14ck137 = 1.8 time = 2760
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=2760.1n

* CHECK dout0_15 Vdout0_15ck137 = 0 time = 2760
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=2760.1n

* CHECK dout0_16 Vdout0_16ck137 = 0 time = 2760
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=2760.1n

* CHECK dout0_17 Vdout0_17ck137 = 1.8 time = 2760
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=2760.1n

* CHECK dout0_18 Vdout0_18ck137 = 0 time = 2760
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=2760.1n

* CHECK dout0_19 Vdout0_19ck137 = 0 time = 2760
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=2760.1n

* CHECK dout0_20 Vdout0_20ck137 = 1.8 time = 2760
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=2760.1n

* CHECK dout0_21 Vdout0_21ck137 = 0 time = 2760
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=2760.1n

* CHECK dout0_22 Vdout0_22ck137 = 1.8 time = 2760
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=2760.1n

* CHECK dout0_23 Vdout0_23ck137 = 1.8 time = 2760
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=2760.1n

* CHECK dout0_24 Vdout0_24ck137 = 0 time = 2760
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=2760.1n

* CHECK dout0_25 Vdout0_25ck137 = 0 time = 2760
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=2760.1n

* CHECK dout0_26 Vdout0_26ck137 = 1.8 time = 2760
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=2760.1n

* CHECK dout0_27 Vdout0_27ck137 = 0 time = 2760
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=2760.1n

* CHECK dout0_28 Vdout0_28ck137 = 0 time = 2760
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=2760.1n

* CHECK dout0_29 Vdout0_29ck137 = 0 time = 2760
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=2760.1n

* CHECK dout0_30 Vdout0_30ck137 = 1.8 time = 2760
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=2760.1n

* CHECK dout0_31 Vdout0_31ck137 = 0 time = 2760
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=2760.1n

* CHECK dout0_0 Vdout0_0ck138 = 0 time = 2780
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=2780.1n

* CHECK dout0_1 Vdout0_1ck138 = 1.8 time = 2780
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=2780.1n

* CHECK dout0_2 Vdout0_2ck138 = 0 time = 2780
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=2780.1n

* CHECK dout0_3 Vdout0_3ck138 = 0 time = 2780
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=2780.1n

* CHECK dout0_4 Vdout0_4ck138 = 1.8 time = 2780
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=2780.1n

* CHECK dout0_5 Vdout0_5ck138 = 0 time = 2780
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=2780.1n

* CHECK dout0_6 Vdout0_6ck138 = 0 time = 2780
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=2780.1n

* CHECK dout0_7 Vdout0_7ck138 = 1.8 time = 2780
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=2780.1n

* CHECK dout0_8 Vdout0_8ck138 = 1.8 time = 2780
.meas tran vdout0_8ck138 FIND v(dout0_8) AT=2780.1n

* CHECK dout0_9 Vdout0_9ck138 = 1.8 time = 2780
.meas tran vdout0_9ck138 FIND v(dout0_9) AT=2780.1n

* CHECK dout0_10 Vdout0_10ck138 = 1.8 time = 2780
.meas tran vdout0_10ck138 FIND v(dout0_10) AT=2780.1n

* CHECK dout0_11 Vdout0_11ck138 = 0 time = 2780
.meas tran vdout0_11ck138 FIND v(dout0_11) AT=2780.1n

* CHECK dout0_12 Vdout0_12ck138 = 0 time = 2780
.meas tran vdout0_12ck138 FIND v(dout0_12) AT=2780.1n

* CHECK dout0_13 Vdout0_13ck138 = 1.8 time = 2780
.meas tran vdout0_13ck138 FIND v(dout0_13) AT=2780.1n

* CHECK dout0_14 Vdout0_14ck138 = 0 time = 2780
.meas tran vdout0_14ck138 FIND v(dout0_14) AT=2780.1n

* CHECK dout0_15 Vdout0_15ck138 = 0 time = 2780
.meas tran vdout0_15ck138 FIND v(dout0_15) AT=2780.1n

* CHECK dout0_16 Vdout0_16ck138 = 0 time = 2780
.meas tran vdout0_16ck138 FIND v(dout0_16) AT=2780.1n

* CHECK dout0_17 Vdout0_17ck138 = 0 time = 2780
.meas tran vdout0_17ck138 FIND v(dout0_17) AT=2780.1n

* CHECK dout0_18 Vdout0_18ck138 = 0 time = 2780
.meas tran vdout0_18ck138 FIND v(dout0_18) AT=2780.1n

* CHECK dout0_19 Vdout0_19ck138 = 1.8 time = 2780
.meas tran vdout0_19ck138 FIND v(dout0_19) AT=2780.1n

* CHECK dout0_20 Vdout0_20ck138 = 0 time = 2780
.meas tran vdout0_20ck138 FIND v(dout0_20) AT=2780.1n

* CHECK dout0_21 Vdout0_21ck138 = 1.8 time = 2780
.meas tran vdout0_21ck138 FIND v(dout0_21) AT=2780.1n

* CHECK dout0_22 Vdout0_22ck138 = 0 time = 2780
.meas tran vdout0_22ck138 FIND v(dout0_22) AT=2780.1n

* CHECK dout0_23 Vdout0_23ck138 = 1.8 time = 2780
.meas tran vdout0_23ck138 FIND v(dout0_23) AT=2780.1n

* CHECK dout0_24 Vdout0_24ck138 = 1.8 time = 2780
.meas tran vdout0_24ck138 FIND v(dout0_24) AT=2780.1n

* CHECK dout0_25 Vdout0_25ck138 = 1.8 time = 2780
.meas tran vdout0_25ck138 FIND v(dout0_25) AT=2780.1n

* CHECK dout0_26 Vdout0_26ck138 = 1.8 time = 2780
.meas tran vdout0_26ck138 FIND v(dout0_26) AT=2780.1n

* CHECK dout0_27 Vdout0_27ck138 = 0 time = 2780
.meas tran vdout0_27ck138 FIND v(dout0_27) AT=2780.1n

* CHECK dout0_28 Vdout0_28ck138 = 0 time = 2780
.meas tran vdout0_28ck138 FIND v(dout0_28) AT=2780.1n

* CHECK dout0_29 Vdout0_29ck138 = 1.8 time = 2780
.meas tran vdout0_29ck138 FIND v(dout0_29) AT=2780.1n

* CHECK dout0_30 Vdout0_30ck138 = 1.8 time = 2780
.meas tran vdout0_30ck138 FIND v(dout0_30) AT=2780.1n

* CHECK dout0_31 Vdout0_31ck138 = 0 time = 2780
.meas tran vdout0_31ck138 FIND v(dout0_31) AT=2780.1n

* CHECK dout0_0 Vdout0_0ck139 = 0 time = 2800
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=2800.1n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 2800
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=2800.1n

* CHECK dout0_2 Vdout0_2ck139 = 1.8 time = 2800
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=2800.1n

* CHECK dout0_3 Vdout0_3ck139 = 1.8 time = 2800
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=2800.1n

* CHECK dout0_4 Vdout0_4ck139 = 0 time = 2800
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=2800.1n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 2800
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=2800.1n

* CHECK dout0_6 Vdout0_6ck139 = 1.8 time = 2800
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=2800.1n

* CHECK dout0_7 Vdout0_7ck139 = 1.8 time = 2800
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=2800.1n

* CHECK dout0_8 Vdout0_8ck139 = 0 time = 2800
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=2800.1n

* CHECK dout0_9 Vdout0_9ck139 = 1.8 time = 2800
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=2800.1n

* CHECK dout0_10 Vdout0_10ck139 = 1.8 time = 2800
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=2800.1n

* CHECK dout0_11 Vdout0_11ck139 = 1.8 time = 2800
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=2800.1n

* CHECK dout0_12 Vdout0_12ck139 = 1.8 time = 2800
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=2800.1n

* CHECK dout0_13 Vdout0_13ck139 = 1.8 time = 2800
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=2800.1n

* CHECK dout0_14 Vdout0_14ck139 = 1.8 time = 2800
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=2800.1n

* CHECK dout0_15 Vdout0_15ck139 = 1.8 time = 2800
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=2800.1n

* CHECK dout0_16 Vdout0_16ck139 = 1.8 time = 2800
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=2800.1n

* CHECK dout0_17 Vdout0_17ck139 = 1.8 time = 2800
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=2800.1n

* CHECK dout0_18 Vdout0_18ck139 = 1.8 time = 2800
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=2800.1n

* CHECK dout0_19 Vdout0_19ck139 = 0 time = 2800
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=2800.1n

* CHECK dout0_20 Vdout0_20ck139 = 1.8 time = 2800
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=2800.1n

* CHECK dout0_21 Vdout0_21ck139 = 1.8 time = 2800
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=2800.1n

* CHECK dout0_22 Vdout0_22ck139 = 1.8 time = 2800
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=2800.1n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 2800
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=2800.1n

* CHECK dout0_24 Vdout0_24ck139 = 0 time = 2800
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=2800.1n

* CHECK dout0_25 Vdout0_25ck139 = 0 time = 2800
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=2800.1n

* CHECK dout0_26 Vdout0_26ck139 = 0 time = 2800
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=2800.1n

* CHECK dout0_27 Vdout0_27ck139 = 1.8 time = 2800
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=2800.1n

* CHECK dout0_28 Vdout0_28ck139 = 0 time = 2800
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=2800.1n

* CHECK dout0_29 Vdout0_29ck139 = 0 time = 2800
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=2800.1n

* CHECK dout0_30 Vdout0_30ck139 = 1.8 time = 2800
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=2800.1n

* CHECK dout0_31 Vdout0_31ck139 = 0 time = 2800
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=2800.1n

* CHECK dout0_0 Vdout0_0ck141 = 0 time = 2840
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=2840.1n

* CHECK dout0_1 Vdout0_1ck141 = 0 time = 2840
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=2840.1n

* CHECK dout0_2 Vdout0_2ck141 = 1.8 time = 2840
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=2840.1n

* CHECK dout0_3 Vdout0_3ck141 = 1.8 time = 2840
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=2840.1n

* CHECK dout0_4 Vdout0_4ck141 = 0 time = 2840
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=2840.1n

* CHECK dout0_5 Vdout0_5ck141 = 1.8 time = 2840
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=2840.1n

* CHECK dout0_6 Vdout0_6ck141 = 1.8 time = 2840
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=2840.1n

* CHECK dout0_7 Vdout0_7ck141 = 1.8 time = 2840
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=2840.1n

* CHECK dout0_8 Vdout0_8ck141 = 0 time = 2840
.meas tran vdout0_8ck141 FIND v(dout0_8) AT=2840.1n

* CHECK dout0_9 Vdout0_9ck141 = 0 time = 2840
.meas tran vdout0_9ck141 FIND v(dout0_9) AT=2840.1n

* CHECK dout0_10 Vdout0_10ck141 = 0 time = 2840
.meas tran vdout0_10ck141 FIND v(dout0_10) AT=2840.1n

* CHECK dout0_11 Vdout0_11ck141 = 0 time = 2840
.meas tran vdout0_11ck141 FIND v(dout0_11) AT=2840.1n

* CHECK dout0_12 Vdout0_12ck141 = 1.8 time = 2840
.meas tran vdout0_12ck141 FIND v(dout0_12) AT=2840.1n

* CHECK dout0_13 Vdout0_13ck141 = 0 time = 2840
.meas tran vdout0_13ck141 FIND v(dout0_13) AT=2840.1n

* CHECK dout0_14 Vdout0_14ck141 = 1.8 time = 2840
.meas tran vdout0_14ck141 FIND v(dout0_14) AT=2840.1n

* CHECK dout0_15 Vdout0_15ck141 = 1.8 time = 2840
.meas tran vdout0_15ck141 FIND v(dout0_15) AT=2840.1n

* CHECK dout0_16 Vdout0_16ck141 = 0 time = 2840
.meas tran vdout0_16ck141 FIND v(dout0_16) AT=2840.1n

* CHECK dout0_17 Vdout0_17ck141 = 0 time = 2840
.meas tran vdout0_17ck141 FIND v(dout0_17) AT=2840.1n

* CHECK dout0_18 Vdout0_18ck141 = 0 time = 2840
.meas tran vdout0_18ck141 FIND v(dout0_18) AT=2840.1n

* CHECK dout0_19 Vdout0_19ck141 = 1.8 time = 2840
.meas tran vdout0_19ck141 FIND v(dout0_19) AT=2840.1n

* CHECK dout0_20 Vdout0_20ck141 = 0 time = 2840
.meas tran vdout0_20ck141 FIND v(dout0_20) AT=2840.1n

* CHECK dout0_21 Vdout0_21ck141 = 0 time = 2840
.meas tran vdout0_21ck141 FIND v(dout0_21) AT=2840.1n

* CHECK dout0_22 Vdout0_22ck141 = 1.8 time = 2840
.meas tran vdout0_22ck141 FIND v(dout0_22) AT=2840.1n

* CHECK dout0_23 Vdout0_23ck141 = 1.8 time = 2840
.meas tran vdout0_23ck141 FIND v(dout0_23) AT=2840.1n

* CHECK dout0_24 Vdout0_24ck141 = 0 time = 2840
.meas tran vdout0_24ck141 FIND v(dout0_24) AT=2840.1n

* CHECK dout0_25 Vdout0_25ck141 = 0 time = 2840
.meas tran vdout0_25ck141 FIND v(dout0_25) AT=2840.1n

* CHECK dout0_26 Vdout0_26ck141 = 1.8 time = 2840
.meas tran vdout0_26ck141 FIND v(dout0_26) AT=2840.1n

* CHECK dout0_27 Vdout0_27ck141 = 0 time = 2840
.meas tran vdout0_27ck141 FIND v(dout0_27) AT=2840.1n

* CHECK dout0_28 Vdout0_28ck141 = 1.8 time = 2840
.meas tran vdout0_28ck141 FIND v(dout0_28) AT=2840.1n

* CHECK dout0_29 Vdout0_29ck141 = 1.8 time = 2840
.meas tran vdout0_29ck141 FIND v(dout0_29) AT=2840.1n

* CHECK dout0_30 Vdout0_30ck141 = 1.8 time = 2840
.meas tran vdout0_30ck141 FIND v(dout0_30) AT=2840.1n

* CHECK dout0_31 Vdout0_31ck141 = 1.8 time = 2840
.meas tran vdout0_31ck141 FIND v(dout0_31) AT=2840.1n

* CHECK dout0_0 Vdout0_0ck142 = 1.8 time = 2860
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=2860.1n

* CHECK dout0_1 Vdout0_1ck142 = 0 time = 2860
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=2860.1n

* CHECK dout0_2 Vdout0_2ck142 = 1.8 time = 2860
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=2860.1n

* CHECK dout0_3 Vdout0_3ck142 = 1.8 time = 2860
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=2860.1n

* CHECK dout0_4 Vdout0_4ck142 = 0 time = 2860
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=2860.1n

* CHECK dout0_5 Vdout0_5ck142 = 1.8 time = 2860
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=2860.1n

* CHECK dout0_6 Vdout0_6ck142 = 1.8 time = 2860
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=2860.1n

* CHECK dout0_7 Vdout0_7ck142 = 1.8 time = 2860
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=2860.1n

* CHECK dout0_8 Vdout0_8ck142 = 1.8 time = 2860
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=2860.1n

* CHECK dout0_9 Vdout0_9ck142 = 1.8 time = 2860
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=2860.1n

* CHECK dout0_10 Vdout0_10ck142 = 1.8 time = 2860
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=2860.1n

* CHECK dout0_11 Vdout0_11ck142 = 1.8 time = 2860
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=2860.1n

* CHECK dout0_12 Vdout0_12ck142 = 0 time = 2860
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=2860.1n

* CHECK dout0_13 Vdout0_13ck142 = 1.8 time = 2860
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=2860.1n

* CHECK dout0_14 Vdout0_14ck142 = 1.8 time = 2860
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=2860.1n

* CHECK dout0_15 Vdout0_15ck142 = 0 time = 2860
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=2860.1n

* CHECK dout0_16 Vdout0_16ck142 = 0 time = 2860
.meas tran vdout0_16ck142 FIND v(dout0_16) AT=2860.1n

* CHECK dout0_17 Vdout0_17ck142 = 1.8 time = 2860
.meas tran vdout0_17ck142 FIND v(dout0_17) AT=2860.1n

* CHECK dout0_18 Vdout0_18ck142 = 1.8 time = 2860
.meas tran vdout0_18ck142 FIND v(dout0_18) AT=2860.1n

* CHECK dout0_19 Vdout0_19ck142 = 1.8 time = 2860
.meas tran vdout0_19ck142 FIND v(dout0_19) AT=2860.1n

* CHECK dout0_20 Vdout0_20ck142 = 1.8 time = 2860
.meas tran vdout0_20ck142 FIND v(dout0_20) AT=2860.1n

* CHECK dout0_21 Vdout0_21ck142 = 1.8 time = 2860
.meas tran vdout0_21ck142 FIND v(dout0_21) AT=2860.1n

* CHECK dout0_22 Vdout0_22ck142 = 0 time = 2860
.meas tran vdout0_22ck142 FIND v(dout0_22) AT=2860.1n

* CHECK dout0_23 Vdout0_23ck142 = 0 time = 2860
.meas tran vdout0_23ck142 FIND v(dout0_23) AT=2860.1n

* CHECK dout0_24 Vdout0_24ck142 = 1.8 time = 2860
.meas tran vdout0_24ck142 FIND v(dout0_24) AT=2860.1n

* CHECK dout0_25 Vdout0_25ck142 = 1.8 time = 2860
.meas tran vdout0_25ck142 FIND v(dout0_25) AT=2860.1n

* CHECK dout0_26 Vdout0_26ck142 = 0 time = 2860
.meas tran vdout0_26ck142 FIND v(dout0_26) AT=2860.1n

* CHECK dout0_27 Vdout0_27ck142 = 1.8 time = 2860
.meas tran vdout0_27ck142 FIND v(dout0_27) AT=2860.1n

* CHECK dout0_28 Vdout0_28ck142 = 1.8 time = 2860
.meas tran vdout0_28ck142 FIND v(dout0_28) AT=2860.1n

* CHECK dout0_29 Vdout0_29ck142 = 1.8 time = 2860
.meas tran vdout0_29ck142 FIND v(dout0_29) AT=2860.1n

* CHECK dout0_30 Vdout0_30ck142 = 1.8 time = 2860
.meas tran vdout0_30ck142 FIND v(dout0_30) AT=2860.1n

* CHECK dout0_31 Vdout0_31ck142 = 0 time = 2860
.meas tran vdout0_31ck142 FIND v(dout0_31) AT=2860.1n

* CHECK dout0_0 Vdout0_0ck146 = 0 time = 2940
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=2940.1n

* CHECK dout0_1 Vdout0_1ck146 = 0 time = 2940
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=2940.1n

* CHECK dout0_2 Vdout0_2ck146 = 0 time = 2940
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=2940.1n

* CHECK dout0_3 Vdout0_3ck146 = 0 time = 2940
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=2940.1n

* CHECK dout0_4 Vdout0_4ck146 = 1.8 time = 2940
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=2940.1n

* CHECK dout0_5 Vdout0_5ck146 = 1.8 time = 2940
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=2940.1n

* CHECK dout0_6 Vdout0_6ck146 = 0 time = 2940
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=2940.1n

* CHECK dout0_7 Vdout0_7ck146 = 0 time = 2940
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=2940.1n

* CHECK dout0_8 Vdout0_8ck146 = 1.8 time = 2940
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=2940.1n

* CHECK dout0_9 Vdout0_9ck146 = 1.8 time = 2940
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=2940.1n

* CHECK dout0_10 Vdout0_10ck146 = 1.8 time = 2940
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=2940.1n

* CHECK dout0_11 Vdout0_11ck146 = 1.8 time = 2940
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=2940.1n

* CHECK dout0_12 Vdout0_12ck146 = 1.8 time = 2940
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=2940.1n

* CHECK dout0_13 Vdout0_13ck146 = 0 time = 2940
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=2940.1n

* CHECK dout0_14 Vdout0_14ck146 = 0 time = 2940
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=2940.1n

* CHECK dout0_15 Vdout0_15ck146 = 1.8 time = 2940
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=2940.1n

* CHECK dout0_16 Vdout0_16ck146 = 1.8 time = 2940
.meas tran vdout0_16ck146 FIND v(dout0_16) AT=2940.1n

* CHECK dout0_17 Vdout0_17ck146 = 0 time = 2940
.meas tran vdout0_17ck146 FIND v(dout0_17) AT=2940.1n

* CHECK dout0_18 Vdout0_18ck146 = 1.8 time = 2940
.meas tran vdout0_18ck146 FIND v(dout0_18) AT=2940.1n

* CHECK dout0_19 Vdout0_19ck146 = 0 time = 2940
.meas tran vdout0_19ck146 FIND v(dout0_19) AT=2940.1n

* CHECK dout0_20 Vdout0_20ck146 = 0 time = 2940
.meas tran vdout0_20ck146 FIND v(dout0_20) AT=2940.1n

* CHECK dout0_21 Vdout0_21ck146 = 0 time = 2940
.meas tran vdout0_21ck146 FIND v(dout0_21) AT=2940.1n

* CHECK dout0_22 Vdout0_22ck146 = 1.8 time = 2940
.meas tran vdout0_22ck146 FIND v(dout0_22) AT=2940.1n

* CHECK dout0_23 Vdout0_23ck146 = 1.8 time = 2940
.meas tran vdout0_23ck146 FIND v(dout0_23) AT=2940.1n

* CHECK dout0_24 Vdout0_24ck146 = 0 time = 2940
.meas tran vdout0_24ck146 FIND v(dout0_24) AT=2940.1n

* CHECK dout0_25 Vdout0_25ck146 = 0 time = 2940
.meas tran vdout0_25ck146 FIND v(dout0_25) AT=2940.1n

* CHECK dout0_26 Vdout0_26ck146 = 1.8 time = 2940
.meas tran vdout0_26ck146 FIND v(dout0_26) AT=2940.1n

* CHECK dout0_27 Vdout0_27ck146 = 0 time = 2940
.meas tran vdout0_27ck146 FIND v(dout0_27) AT=2940.1n

* CHECK dout0_28 Vdout0_28ck146 = 0 time = 2940
.meas tran vdout0_28ck146 FIND v(dout0_28) AT=2940.1n

* CHECK dout0_29 Vdout0_29ck146 = 1.8 time = 2940
.meas tran vdout0_29ck146 FIND v(dout0_29) AT=2940.1n

* CHECK dout0_30 Vdout0_30ck146 = 0 time = 2940
.meas tran vdout0_30ck146 FIND v(dout0_30) AT=2940.1n

* CHECK dout0_31 Vdout0_31ck146 = 1.8 time = 2940
.meas tran vdout0_31ck146 FIND v(dout0_31) AT=2940.1n

* CHECK dout0_0 Vdout0_0ck147 = 0 time = 2960
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=2960.1n

* CHECK dout0_1 Vdout0_1ck147 = 0 time = 2960
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=2960.1n

* CHECK dout0_2 Vdout0_2ck147 = 1.8 time = 2960
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=2960.1n

* CHECK dout0_3 Vdout0_3ck147 = 1.8 time = 2960
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=2960.1n

* CHECK dout0_4 Vdout0_4ck147 = 0 time = 2960
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=2960.1n

* CHECK dout0_5 Vdout0_5ck147 = 0 time = 2960
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=2960.1n

* CHECK dout0_6 Vdout0_6ck147 = 1.8 time = 2960
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=2960.1n

* CHECK dout0_7 Vdout0_7ck147 = 1.8 time = 2960
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=2960.1n

* CHECK dout0_8 Vdout0_8ck147 = 0 time = 2960
.meas tran vdout0_8ck147 FIND v(dout0_8) AT=2960.1n

* CHECK dout0_9 Vdout0_9ck147 = 1.8 time = 2960
.meas tran vdout0_9ck147 FIND v(dout0_9) AT=2960.1n

* CHECK dout0_10 Vdout0_10ck147 = 1.8 time = 2960
.meas tran vdout0_10ck147 FIND v(dout0_10) AT=2960.1n

* CHECK dout0_11 Vdout0_11ck147 = 1.8 time = 2960
.meas tran vdout0_11ck147 FIND v(dout0_11) AT=2960.1n

* CHECK dout0_12 Vdout0_12ck147 = 1.8 time = 2960
.meas tran vdout0_12ck147 FIND v(dout0_12) AT=2960.1n

* CHECK dout0_13 Vdout0_13ck147 = 1.8 time = 2960
.meas tran vdout0_13ck147 FIND v(dout0_13) AT=2960.1n

* CHECK dout0_14 Vdout0_14ck147 = 1.8 time = 2960
.meas tran vdout0_14ck147 FIND v(dout0_14) AT=2960.1n

* CHECK dout0_15 Vdout0_15ck147 = 1.8 time = 2960
.meas tran vdout0_15ck147 FIND v(dout0_15) AT=2960.1n

* CHECK dout0_16 Vdout0_16ck147 = 1.8 time = 2960
.meas tran vdout0_16ck147 FIND v(dout0_16) AT=2960.1n

* CHECK dout0_17 Vdout0_17ck147 = 1.8 time = 2960
.meas tran vdout0_17ck147 FIND v(dout0_17) AT=2960.1n

* CHECK dout0_18 Vdout0_18ck147 = 1.8 time = 2960
.meas tran vdout0_18ck147 FIND v(dout0_18) AT=2960.1n

* CHECK dout0_19 Vdout0_19ck147 = 0 time = 2960
.meas tran vdout0_19ck147 FIND v(dout0_19) AT=2960.1n

* CHECK dout0_20 Vdout0_20ck147 = 1.8 time = 2960
.meas tran vdout0_20ck147 FIND v(dout0_20) AT=2960.1n

* CHECK dout0_21 Vdout0_21ck147 = 1.8 time = 2960
.meas tran vdout0_21ck147 FIND v(dout0_21) AT=2960.1n

* CHECK dout0_22 Vdout0_22ck147 = 1.8 time = 2960
.meas tran vdout0_22ck147 FIND v(dout0_22) AT=2960.1n

* CHECK dout0_23 Vdout0_23ck147 = 0 time = 2960
.meas tran vdout0_23ck147 FIND v(dout0_23) AT=2960.1n

* CHECK dout0_24 Vdout0_24ck147 = 0 time = 2960
.meas tran vdout0_24ck147 FIND v(dout0_24) AT=2960.1n

* CHECK dout0_25 Vdout0_25ck147 = 0 time = 2960
.meas tran vdout0_25ck147 FIND v(dout0_25) AT=2960.1n

* CHECK dout0_26 Vdout0_26ck147 = 0 time = 2960
.meas tran vdout0_26ck147 FIND v(dout0_26) AT=2960.1n

* CHECK dout0_27 Vdout0_27ck147 = 1.8 time = 2960
.meas tran vdout0_27ck147 FIND v(dout0_27) AT=2960.1n

* CHECK dout0_28 Vdout0_28ck147 = 0 time = 2960
.meas tran vdout0_28ck147 FIND v(dout0_28) AT=2960.1n

* CHECK dout0_29 Vdout0_29ck147 = 0 time = 2960
.meas tran vdout0_29ck147 FIND v(dout0_29) AT=2960.1n

* CHECK dout0_30 Vdout0_30ck147 = 1.8 time = 2960
.meas tran vdout0_30ck147 FIND v(dout0_30) AT=2960.1n

* CHECK dout0_31 Vdout0_31ck147 = 0 time = 2960
.meas tran vdout0_31ck147 FIND v(dout0_31) AT=2960.1n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 2980
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=2980.1n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 2980
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=2980.1n

* CHECK dout0_2 Vdout0_2ck148 = 1.8 time = 2980
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=2980.1n

* CHECK dout0_3 Vdout0_3ck148 = 0 time = 2980
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=2980.1n

* CHECK dout0_4 Vdout0_4ck148 = 0 time = 2980
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=2980.1n

* CHECK dout0_5 Vdout0_5ck148 = 0 time = 2980
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=2980.1n

* CHECK dout0_6 Vdout0_6ck148 = 1.8 time = 2980
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=2980.1n

* CHECK dout0_7 Vdout0_7ck148 = 0 time = 2980
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=2980.1n

* CHECK dout0_8 Vdout0_8ck148 = 0 time = 2980
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=2980.1n

* CHECK dout0_9 Vdout0_9ck148 = 0 time = 2980
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=2980.1n

* CHECK dout0_10 Vdout0_10ck148 = 1.8 time = 2980
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=2980.1n

* CHECK dout0_11 Vdout0_11ck148 = 1.8 time = 2980
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=2980.1n

* CHECK dout0_12 Vdout0_12ck148 = 0 time = 2980
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=2980.1n

* CHECK dout0_13 Vdout0_13ck148 = 1.8 time = 2980
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=2980.1n

* CHECK dout0_14 Vdout0_14ck148 = 0 time = 2980
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=2980.1n

* CHECK dout0_15 Vdout0_15ck148 = 0 time = 2980
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=2980.1n

* CHECK dout0_16 Vdout0_16ck148 = 1.8 time = 2980
.meas tran vdout0_16ck148 FIND v(dout0_16) AT=2980.1n

* CHECK dout0_17 Vdout0_17ck148 = 0 time = 2980
.meas tran vdout0_17ck148 FIND v(dout0_17) AT=2980.1n

* CHECK dout0_18 Vdout0_18ck148 = 0 time = 2980
.meas tran vdout0_18ck148 FIND v(dout0_18) AT=2980.1n

* CHECK dout0_19 Vdout0_19ck148 = 1.8 time = 2980
.meas tran vdout0_19ck148 FIND v(dout0_19) AT=2980.1n

* CHECK dout0_20 Vdout0_20ck148 = 1.8 time = 2980
.meas tran vdout0_20ck148 FIND v(dout0_20) AT=2980.1n

* CHECK dout0_21 Vdout0_21ck148 = 0 time = 2980
.meas tran vdout0_21ck148 FIND v(dout0_21) AT=2980.1n

* CHECK dout0_22 Vdout0_22ck148 = 0 time = 2980
.meas tran vdout0_22ck148 FIND v(dout0_22) AT=2980.1n

* CHECK dout0_23 Vdout0_23ck148 = 1.8 time = 2980
.meas tran vdout0_23ck148 FIND v(dout0_23) AT=2980.1n

* CHECK dout0_24 Vdout0_24ck148 = 0 time = 2980
.meas tran vdout0_24ck148 FIND v(dout0_24) AT=2980.1n

* CHECK dout0_25 Vdout0_25ck148 = 1.8 time = 2980
.meas tran vdout0_25ck148 FIND v(dout0_25) AT=2980.1n

* CHECK dout0_26 Vdout0_26ck148 = 1.8 time = 2980
.meas tran vdout0_26ck148 FIND v(dout0_26) AT=2980.1n

* CHECK dout0_27 Vdout0_27ck148 = 0 time = 2980
.meas tran vdout0_27ck148 FIND v(dout0_27) AT=2980.1n

* CHECK dout0_28 Vdout0_28ck148 = 1.8 time = 2980
.meas tran vdout0_28ck148 FIND v(dout0_28) AT=2980.1n

* CHECK dout0_29 Vdout0_29ck148 = 1.8 time = 2980
.meas tran vdout0_29ck148 FIND v(dout0_29) AT=2980.1n

* CHECK dout0_30 Vdout0_30ck148 = 0 time = 2980
.meas tran vdout0_30ck148 FIND v(dout0_30) AT=2980.1n

* CHECK dout0_31 Vdout0_31ck148 = 1.8 time = 2980
.meas tran vdout0_31ck148 FIND v(dout0_31) AT=2980.1n

* CHECK dout0_0 Vdout0_0ck151 = 0 time = 3040
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=3040.1n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 3040
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=3040.1n

* CHECK dout0_2 Vdout0_2ck151 = 0 time = 3040
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=3040.1n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 3040
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=3040.1n

* CHECK dout0_4 Vdout0_4ck151 = 1.8 time = 3040
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=3040.1n

* CHECK dout0_5 Vdout0_5ck151 = 1.8 time = 3040
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=3040.1n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 3040
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=3040.1n

* CHECK dout0_7 Vdout0_7ck151 = 0 time = 3040
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=3040.1n

* CHECK dout0_8 Vdout0_8ck151 = 1.8 time = 3040
.meas tran vdout0_8ck151 FIND v(dout0_8) AT=3040.1n

* CHECK dout0_9 Vdout0_9ck151 = 1.8 time = 3040
.meas tran vdout0_9ck151 FIND v(dout0_9) AT=3040.1n

* CHECK dout0_10 Vdout0_10ck151 = 1.8 time = 3040
.meas tran vdout0_10ck151 FIND v(dout0_10) AT=3040.1n

* CHECK dout0_11 Vdout0_11ck151 = 1.8 time = 3040
.meas tran vdout0_11ck151 FIND v(dout0_11) AT=3040.1n

* CHECK dout0_12 Vdout0_12ck151 = 1.8 time = 3040
.meas tran vdout0_12ck151 FIND v(dout0_12) AT=3040.1n

* CHECK dout0_13 Vdout0_13ck151 = 0 time = 3040
.meas tran vdout0_13ck151 FIND v(dout0_13) AT=3040.1n

* CHECK dout0_14 Vdout0_14ck151 = 0 time = 3040
.meas tran vdout0_14ck151 FIND v(dout0_14) AT=3040.1n

* CHECK dout0_15 Vdout0_15ck151 = 1.8 time = 3040
.meas tran vdout0_15ck151 FIND v(dout0_15) AT=3040.1n

* CHECK dout0_16 Vdout0_16ck151 = 1.8 time = 3040
.meas tran vdout0_16ck151 FIND v(dout0_16) AT=3040.1n

* CHECK dout0_17 Vdout0_17ck151 = 0 time = 3040
.meas tran vdout0_17ck151 FIND v(dout0_17) AT=3040.1n

* CHECK dout0_18 Vdout0_18ck151 = 1.8 time = 3040
.meas tran vdout0_18ck151 FIND v(dout0_18) AT=3040.1n

* CHECK dout0_19 Vdout0_19ck151 = 0 time = 3040
.meas tran vdout0_19ck151 FIND v(dout0_19) AT=3040.1n

* CHECK dout0_20 Vdout0_20ck151 = 0 time = 3040
.meas tran vdout0_20ck151 FIND v(dout0_20) AT=3040.1n

* CHECK dout0_21 Vdout0_21ck151 = 0 time = 3040
.meas tran vdout0_21ck151 FIND v(dout0_21) AT=3040.1n

* CHECK dout0_22 Vdout0_22ck151 = 1.8 time = 3040
.meas tran vdout0_22ck151 FIND v(dout0_22) AT=3040.1n

* CHECK dout0_23 Vdout0_23ck151 = 1.8 time = 3040
.meas tran vdout0_23ck151 FIND v(dout0_23) AT=3040.1n

* CHECK dout0_24 Vdout0_24ck151 = 0 time = 3040
.meas tran vdout0_24ck151 FIND v(dout0_24) AT=3040.1n

* CHECK dout0_25 Vdout0_25ck151 = 0 time = 3040
.meas tran vdout0_25ck151 FIND v(dout0_25) AT=3040.1n

* CHECK dout0_26 Vdout0_26ck151 = 1.8 time = 3040
.meas tran vdout0_26ck151 FIND v(dout0_26) AT=3040.1n

* CHECK dout0_27 Vdout0_27ck151 = 0 time = 3040
.meas tran vdout0_27ck151 FIND v(dout0_27) AT=3040.1n

* CHECK dout0_28 Vdout0_28ck151 = 0 time = 3040
.meas tran vdout0_28ck151 FIND v(dout0_28) AT=3040.1n

* CHECK dout0_29 Vdout0_29ck151 = 1.8 time = 3040
.meas tran vdout0_29ck151 FIND v(dout0_29) AT=3040.1n

* CHECK dout0_30 Vdout0_30ck151 = 0 time = 3040
.meas tran vdout0_30ck151 FIND v(dout0_30) AT=3040.1n

* CHECK dout0_31 Vdout0_31ck151 = 1.8 time = 3040
.meas tran vdout0_31ck151 FIND v(dout0_31) AT=3040.1n

* CHECK dout0_0 Vdout0_0ck152 = 0 time = 3060
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=3060.1n

* CHECK dout0_1 Vdout0_1ck152 = 0 time = 3060
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=3060.1n

* CHECK dout0_2 Vdout0_2ck152 = 0 time = 3060
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=3060.1n

* CHECK dout0_3 Vdout0_3ck152 = 0 time = 3060
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=3060.1n

* CHECK dout0_4 Vdout0_4ck152 = 1.8 time = 3060
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=3060.1n

* CHECK dout0_5 Vdout0_5ck152 = 1.8 time = 3060
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=3060.1n

* CHECK dout0_6 Vdout0_6ck152 = 0 time = 3060
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=3060.1n

* CHECK dout0_7 Vdout0_7ck152 = 0 time = 3060
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=3060.1n

* CHECK dout0_8 Vdout0_8ck152 = 1.8 time = 3060
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=3060.1n

* CHECK dout0_9 Vdout0_9ck152 = 1.8 time = 3060
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=3060.1n

* CHECK dout0_10 Vdout0_10ck152 = 1.8 time = 3060
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=3060.1n

* CHECK dout0_11 Vdout0_11ck152 = 1.8 time = 3060
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=3060.1n

* CHECK dout0_12 Vdout0_12ck152 = 1.8 time = 3060
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=3060.1n

* CHECK dout0_13 Vdout0_13ck152 = 0 time = 3060
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=3060.1n

* CHECK dout0_14 Vdout0_14ck152 = 0 time = 3060
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=3060.1n

* CHECK dout0_15 Vdout0_15ck152 = 1.8 time = 3060
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=3060.1n

* CHECK dout0_16 Vdout0_16ck152 = 1.8 time = 3060
.meas tran vdout0_16ck152 FIND v(dout0_16) AT=3060.1n

* CHECK dout0_17 Vdout0_17ck152 = 0 time = 3060
.meas tran vdout0_17ck152 FIND v(dout0_17) AT=3060.1n

* CHECK dout0_18 Vdout0_18ck152 = 1.8 time = 3060
.meas tran vdout0_18ck152 FIND v(dout0_18) AT=3060.1n

* CHECK dout0_19 Vdout0_19ck152 = 0 time = 3060
.meas tran vdout0_19ck152 FIND v(dout0_19) AT=3060.1n

* CHECK dout0_20 Vdout0_20ck152 = 0 time = 3060
.meas tran vdout0_20ck152 FIND v(dout0_20) AT=3060.1n

* CHECK dout0_21 Vdout0_21ck152 = 0 time = 3060
.meas tran vdout0_21ck152 FIND v(dout0_21) AT=3060.1n

* CHECK dout0_22 Vdout0_22ck152 = 1.8 time = 3060
.meas tran vdout0_22ck152 FIND v(dout0_22) AT=3060.1n

* CHECK dout0_23 Vdout0_23ck152 = 1.8 time = 3060
.meas tran vdout0_23ck152 FIND v(dout0_23) AT=3060.1n

* CHECK dout0_24 Vdout0_24ck152 = 0 time = 3060
.meas tran vdout0_24ck152 FIND v(dout0_24) AT=3060.1n

* CHECK dout0_25 Vdout0_25ck152 = 0 time = 3060
.meas tran vdout0_25ck152 FIND v(dout0_25) AT=3060.1n

* CHECK dout0_26 Vdout0_26ck152 = 1.8 time = 3060
.meas tran vdout0_26ck152 FIND v(dout0_26) AT=3060.1n

* CHECK dout0_27 Vdout0_27ck152 = 0 time = 3060
.meas tran vdout0_27ck152 FIND v(dout0_27) AT=3060.1n

* CHECK dout0_28 Vdout0_28ck152 = 0 time = 3060
.meas tran vdout0_28ck152 FIND v(dout0_28) AT=3060.1n

* CHECK dout0_29 Vdout0_29ck152 = 1.8 time = 3060
.meas tran vdout0_29ck152 FIND v(dout0_29) AT=3060.1n

* CHECK dout0_30 Vdout0_30ck152 = 0 time = 3060
.meas tran vdout0_30ck152 FIND v(dout0_30) AT=3060.1n

* CHECK dout0_31 Vdout0_31ck152 = 1.8 time = 3060
.meas tran vdout0_31ck152 FIND v(dout0_31) AT=3060.1n

* CHECK dout0_0 Vdout0_0ck155 = 0 time = 3120
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=3120.1n

* CHECK dout0_1 Vdout0_1ck155 = 0 time = 3120
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=3120.1n

* CHECK dout0_2 Vdout0_2ck155 = 1.8 time = 3120
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=3120.1n

* CHECK dout0_3 Vdout0_3ck155 = 1.8 time = 3120
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=3120.1n

* CHECK dout0_4 Vdout0_4ck155 = 1.8 time = 3120
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=3120.1n

* CHECK dout0_5 Vdout0_5ck155 = 1.8 time = 3120
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=3120.1n

* CHECK dout0_6 Vdout0_6ck155 = 0 time = 3120
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=3120.1n

* CHECK dout0_7 Vdout0_7ck155 = 0 time = 3120
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=3120.1n

* CHECK dout0_8 Vdout0_8ck155 = 0 time = 3120
.meas tran vdout0_8ck155 FIND v(dout0_8) AT=3120.1n

* CHECK dout0_9 Vdout0_9ck155 = 1.8 time = 3120
.meas tran vdout0_9ck155 FIND v(dout0_9) AT=3120.1n

* CHECK dout0_10 Vdout0_10ck155 = 0 time = 3120
.meas tran vdout0_10ck155 FIND v(dout0_10) AT=3120.1n

* CHECK dout0_11 Vdout0_11ck155 = 0 time = 3120
.meas tran vdout0_11ck155 FIND v(dout0_11) AT=3120.1n

* CHECK dout0_12 Vdout0_12ck155 = 1.8 time = 3120
.meas tran vdout0_12ck155 FIND v(dout0_12) AT=3120.1n

* CHECK dout0_13 Vdout0_13ck155 = 1.8 time = 3120
.meas tran vdout0_13ck155 FIND v(dout0_13) AT=3120.1n

* CHECK dout0_14 Vdout0_14ck155 = 1.8 time = 3120
.meas tran vdout0_14ck155 FIND v(dout0_14) AT=3120.1n

* CHECK dout0_15 Vdout0_15ck155 = 0 time = 3120
.meas tran vdout0_15ck155 FIND v(dout0_15) AT=3120.1n

* CHECK dout0_16 Vdout0_16ck155 = 1.8 time = 3120
.meas tran vdout0_16ck155 FIND v(dout0_16) AT=3120.1n

* CHECK dout0_17 Vdout0_17ck155 = 0 time = 3120
.meas tran vdout0_17ck155 FIND v(dout0_17) AT=3120.1n

* CHECK dout0_18 Vdout0_18ck155 = 1.8 time = 3120
.meas tran vdout0_18ck155 FIND v(dout0_18) AT=3120.1n

* CHECK dout0_19 Vdout0_19ck155 = 0 time = 3120
.meas tran vdout0_19ck155 FIND v(dout0_19) AT=3120.1n

* CHECK dout0_20 Vdout0_20ck155 = 0 time = 3120
.meas tran vdout0_20ck155 FIND v(dout0_20) AT=3120.1n

* CHECK dout0_21 Vdout0_21ck155 = 0 time = 3120
.meas tran vdout0_21ck155 FIND v(dout0_21) AT=3120.1n

* CHECK dout0_22 Vdout0_22ck155 = 0 time = 3120
.meas tran vdout0_22ck155 FIND v(dout0_22) AT=3120.1n

* CHECK dout0_23 Vdout0_23ck155 = 1.8 time = 3120
.meas tran vdout0_23ck155 FIND v(dout0_23) AT=3120.1n

* CHECK dout0_24 Vdout0_24ck155 = 1.8 time = 3120
.meas tran vdout0_24ck155 FIND v(dout0_24) AT=3120.1n

* CHECK dout0_25 Vdout0_25ck155 = 1.8 time = 3120
.meas tran vdout0_25ck155 FIND v(dout0_25) AT=3120.1n

* CHECK dout0_26 Vdout0_26ck155 = 1.8 time = 3120
.meas tran vdout0_26ck155 FIND v(dout0_26) AT=3120.1n

* CHECK dout0_27 Vdout0_27ck155 = 1.8 time = 3120
.meas tran vdout0_27ck155 FIND v(dout0_27) AT=3120.1n

* CHECK dout0_28 Vdout0_28ck155 = 0 time = 3120
.meas tran vdout0_28ck155 FIND v(dout0_28) AT=3120.1n

* CHECK dout0_29 Vdout0_29ck155 = 0 time = 3120
.meas tran vdout0_29ck155 FIND v(dout0_29) AT=3120.1n

* CHECK dout0_30 Vdout0_30ck155 = 0 time = 3120
.meas tran vdout0_30ck155 FIND v(dout0_30) AT=3120.1n

* CHECK dout0_31 Vdout0_31ck155 = 1.8 time = 3120
.meas tran vdout0_31ck155 FIND v(dout0_31) AT=3120.1n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 3180
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=3180.1n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 3180
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=3180.1n

* CHECK dout0_2 Vdout0_2ck158 = 1.8 time = 3180
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=3180.1n

* CHECK dout0_3 Vdout0_3ck158 = 1.8 time = 3180
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=3180.1n

* CHECK dout0_4 Vdout0_4ck158 = 0 time = 3180
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=3180.1n

* CHECK dout0_5 Vdout0_5ck158 = 1.8 time = 3180
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=3180.1n

* CHECK dout0_6 Vdout0_6ck158 = 1.8 time = 3180
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=3180.1n

* CHECK dout0_7 Vdout0_7ck158 = 1.8 time = 3180
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=3180.1n

* CHECK dout0_8 Vdout0_8ck158 = 0 time = 3180
.meas tran vdout0_8ck158 FIND v(dout0_8) AT=3180.1n

* CHECK dout0_9 Vdout0_9ck158 = 0 time = 3180
.meas tran vdout0_9ck158 FIND v(dout0_9) AT=3180.1n

* CHECK dout0_10 Vdout0_10ck158 = 0 time = 3180
.meas tran vdout0_10ck158 FIND v(dout0_10) AT=3180.1n

* CHECK dout0_11 Vdout0_11ck158 = 0 time = 3180
.meas tran vdout0_11ck158 FIND v(dout0_11) AT=3180.1n

* CHECK dout0_12 Vdout0_12ck158 = 1.8 time = 3180
.meas tran vdout0_12ck158 FIND v(dout0_12) AT=3180.1n

* CHECK dout0_13 Vdout0_13ck158 = 0 time = 3180
.meas tran vdout0_13ck158 FIND v(dout0_13) AT=3180.1n

* CHECK dout0_14 Vdout0_14ck158 = 1.8 time = 3180
.meas tran vdout0_14ck158 FIND v(dout0_14) AT=3180.1n

* CHECK dout0_15 Vdout0_15ck158 = 1.8 time = 3180
.meas tran vdout0_15ck158 FIND v(dout0_15) AT=3180.1n

* CHECK dout0_16 Vdout0_16ck158 = 0 time = 3180
.meas tran vdout0_16ck158 FIND v(dout0_16) AT=3180.1n

* CHECK dout0_17 Vdout0_17ck158 = 0 time = 3180
.meas tran vdout0_17ck158 FIND v(dout0_17) AT=3180.1n

* CHECK dout0_18 Vdout0_18ck158 = 0 time = 3180
.meas tran vdout0_18ck158 FIND v(dout0_18) AT=3180.1n

* CHECK dout0_19 Vdout0_19ck158 = 1.8 time = 3180
.meas tran vdout0_19ck158 FIND v(dout0_19) AT=3180.1n

* CHECK dout0_20 Vdout0_20ck158 = 0 time = 3180
.meas tran vdout0_20ck158 FIND v(dout0_20) AT=3180.1n

* CHECK dout0_21 Vdout0_21ck158 = 0 time = 3180
.meas tran vdout0_21ck158 FIND v(dout0_21) AT=3180.1n

* CHECK dout0_22 Vdout0_22ck158 = 1.8 time = 3180
.meas tran vdout0_22ck158 FIND v(dout0_22) AT=3180.1n

* CHECK dout0_23 Vdout0_23ck158 = 1.8 time = 3180
.meas tran vdout0_23ck158 FIND v(dout0_23) AT=3180.1n

* CHECK dout0_24 Vdout0_24ck158 = 0 time = 3180
.meas tran vdout0_24ck158 FIND v(dout0_24) AT=3180.1n

* CHECK dout0_25 Vdout0_25ck158 = 0 time = 3180
.meas tran vdout0_25ck158 FIND v(dout0_25) AT=3180.1n

* CHECK dout0_26 Vdout0_26ck158 = 1.8 time = 3180
.meas tran vdout0_26ck158 FIND v(dout0_26) AT=3180.1n

* CHECK dout0_27 Vdout0_27ck158 = 0 time = 3180
.meas tran vdout0_27ck158 FIND v(dout0_27) AT=3180.1n

* CHECK dout0_28 Vdout0_28ck158 = 1.8 time = 3180
.meas tran vdout0_28ck158 FIND v(dout0_28) AT=3180.1n

* CHECK dout0_29 Vdout0_29ck158 = 1.8 time = 3180
.meas tran vdout0_29ck158 FIND v(dout0_29) AT=3180.1n

* CHECK dout0_30 Vdout0_30ck158 = 1.8 time = 3180
.meas tran vdout0_30ck158 FIND v(dout0_30) AT=3180.1n

* CHECK dout0_31 Vdout0_31ck158 = 1.8 time = 3180
.meas tran vdout0_31ck158 FIND v(dout0_31) AT=3180.1n

* CHECK dout0_0 Vdout0_0ck159 = 1.8 time = 3200
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=3200.1n

* CHECK dout0_1 Vdout0_1ck159 = 0 time = 3200
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=3200.1n

* CHECK dout0_2 Vdout0_2ck159 = 0 time = 3200
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=3200.1n

* CHECK dout0_3 Vdout0_3ck159 = 1.8 time = 3200
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=3200.1n

* CHECK dout0_4 Vdout0_4ck159 = 0 time = 3200
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=3200.1n

* CHECK dout0_5 Vdout0_5ck159 = 1.8 time = 3200
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=3200.1n

* CHECK dout0_6 Vdout0_6ck159 = 0 time = 3200
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=3200.1n

* CHECK dout0_7 Vdout0_7ck159 = 0 time = 3200
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=3200.1n

* CHECK dout0_8 Vdout0_8ck159 = 1.8 time = 3200
.meas tran vdout0_8ck159 FIND v(dout0_8) AT=3200.1n

* CHECK dout0_9 Vdout0_9ck159 = 1.8 time = 3200
.meas tran vdout0_9ck159 FIND v(dout0_9) AT=3200.1n

* CHECK dout0_10 Vdout0_10ck159 = 0 time = 3200
.meas tran vdout0_10ck159 FIND v(dout0_10) AT=3200.1n

* CHECK dout0_11 Vdout0_11ck159 = 0 time = 3200
.meas tran vdout0_11ck159 FIND v(dout0_11) AT=3200.1n

* CHECK dout0_12 Vdout0_12ck159 = 0 time = 3200
.meas tran vdout0_12ck159 FIND v(dout0_12) AT=3200.1n

* CHECK dout0_13 Vdout0_13ck159 = 1.8 time = 3200
.meas tran vdout0_13ck159 FIND v(dout0_13) AT=3200.1n

* CHECK dout0_14 Vdout0_14ck159 = 1.8 time = 3200
.meas tran vdout0_14ck159 FIND v(dout0_14) AT=3200.1n

* CHECK dout0_15 Vdout0_15ck159 = 1.8 time = 3200
.meas tran vdout0_15ck159 FIND v(dout0_15) AT=3200.1n

* CHECK dout0_16 Vdout0_16ck159 = 0 time = 3200
.meas tran vdout0_16ck159 FIND v(dout0_16) AT=3200.1n

* CHECK dout0_17 Vdout0_17ck159 = 0 time = 3200
.meas tran vdout0_17ck159 FIND v(dout0_17) AT=3200.1n

* CHECK dout0_18 Vdout0_18ck159 = 0 time = 3200
.meas tran vdout0_18ck159 FIND v(dout0_18) AT=3200.1n

* CHECK dout0_19 Vdout0_19ck159 = 1.8 time = 3200
.meas tran vdout0_19ck159 FIND v(dout0_19) AT=3200.1n

* CHECK dout0_20 Vdout0_20ck159 = 0 time = 3200
.meas tran vdout0_20ck159 FIND v(dout0_20) AT=3200.1n

* CHECK dout0_21 Vdout0_21ck159 = 1.8 time = 3200
.meas tran vdout0_21ck159 FIND v(dout0_21) AT=3200.1n

* CHECK dout0_22 Vdout0_22ck159 = 1.8 time = 3200
.meas tran vdout0_22ck159 FIND v(dout0_22) AT=3200.1n

* CHECK dout0_23 Vdout0_23ck159 = 1.8 time = 3200
.meas tran vdout0_23ck159 FIND v(dout0_23) AT=3200.1n

* CHECK dout0_24 Vdout0_24ck159 = 0 time = 3200
.meas tran vdout0_24ck159 FIND v(dout0_24) AT=3200.1n

* CHECK dout0_25 Vdout0_25ck159 = 1.8 time = 3200
.meas tran vdout0_25ck159 FIND v(dout0_25) AT=3200.1n

* CHECK dout0_26 Vdout0_26ck159 = 1.8 time = 3200
.meas tran vdout0_26ck159 FIND v(dout0_26) AT=3200.1n

* CHECK dout0_27 Vdout0_27ck159 = 0 time = 3200
.meas tran vdout0_27ck159 FIND v(dout0_27) AT=3200.1n

* CHECK dout0_28 Vdout0_28ck159 = 0 time = 3200
.meas tran vdout0_28ck159 FIND v(dout0_28) AT=3200.1n

* CHECK dout0_29 Vdout0_29ck159 = 0 time = 3200
.meas tran vdout0_29ck159 FIND v(dout0_29) AT=3200.1n

* CHECK dout0_30 Vdout0_30ck159 = 1.8 time = 3200
.meas tran vdout0_30ck159 FIND v(dout0_30) AT=3200.1n

* CHECK dout0_31 Vdout0_31ck159 = 0 time = 3200
.meas tran vdout0_31ck159 FIND v(dout0_31) AT=3200.1n

* CHECK dout0_0 Vdout0_0ck161 = 1.8 time = 3240
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=3240.1n

* CHECK dout0_1 Vdout0_1ck161 = 0 time = 3240
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=3240.1n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 3240
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=3240.1n

* CHECK dout0_3 Vdout0_3ck161 = 0 time = 3240
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=3240.1n

* CHECK dout0_4 Vdout0_4ck161 = 1.8 time = 3240
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=3240.1n

* CHECK dout0_5 Vdout0_5ck161 = 1.8 time = 3240
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=3240.1n

* CHECK dout0_6 Vdout0_6ck161 = 1.8 time = 3240
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=3240.1n

* CHECK dout0_7 Vdout0_7ck161 = 1.8 time = 3240
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=3240.1n

* CHECK dout0_8 Vdout0_8ck161 = 1.8 time = 3240
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=3240.1n

* CHECK dout0_9 Vdout0_9ck161 = 0 time = 3240
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=3240.1n

* CHECK dout0_10 Vdout0_10ck161 = 0 time = 3240
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=3240.1n

* CHECK dout0_11 Vdout0_11ck161 = 1.8 time = 3240
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=3240.1n

* CHECK dout0_12 Vdout0_12ck161 = 0 time = 3240
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=3240.1n

* CHECK dout0_13 Vdout0_13ck161 = 0 time = 3240
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=3240.1n

* CHECK dout0_14 Vdout0_14ck161 = 0 time = 3240
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=3240.1n

* CHECK dout0_15 Vdout0_15ck161 = 1.8 time = 3240
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=3240.1n

* CHECK dout0_16 Vdout0_16ck161 = 1.8 time = 3240
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=3240.1n

* CHECK dout0_17 Vdout0_17ck161 = 0 time = 3240
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=3240.1n

* CHECK dout0_18 Vdout0_18ck161 = 0 time = 3240
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=3240.1n

* CHECK dout0_19 Vdout0_19ck161 = 1.8 time = 3240
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=3240.1n

* CHECK dout0_20 Vdout0_20ck161 = 0 time = 3240
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=3240.1n

* CHECK dout0_21 Vdout0_21ck161 = 1.8 time = 3240
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=3240.1n

* CHECK dout0_22 Vdout0_22ck161 = 1.8 time = 3240
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=3240.1n

* CHECK dout0_23 Vdout0_23ck161 = 0 time = 3240
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=3240.1n

* CHECK dout0_24 Vdout0_24ck161 = 0 time = 3240
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=3240.1n

* CHECK dout0_25 Vdout0_25ck161 = 0 time = 3240
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=3240.1n

* CHECK dout0_26 Vdout0_26ck161 = 1.8 time = 3240
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=3240.1n

* CHECK dout0_27 Vdout0_27ck161 = 0 time = 3240
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=3240.1n

* CHECK dout0_28 Vdout0_28ck161 = 0 time = 3240
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=3240.1n

* CHECK dout0_29 Vdout0_29ck161 = 1.8 time = 3240
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=3240.1n

* CHECK dout0_30 Vdout0_30ck161 = 1.8 time = 3240
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=3240.1n

* CHECK dout0_31 Vdout0_31ck161 = 0 time = 3240
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=3240.1n

* CHECK dout0_0 Vdout0_0ck162 = 1.8 time = 3260
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=3260.1n

* CHECK dout0_1 Vdout0_1ck162 = 1.8 time = 3260
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=3260.1n

* CHECK dout0_2 Vdout0_2ck162 = 0 time = 3260
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=3260.1n

* CHECK dout0_3 Vdout0_3ck162 = 1.8 time = 3260
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=3260.1n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 3260
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=3260.1n

* CHECK dout0_5 Vdout0_5ck162 = 0 time = 3260
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=3260.1n

* CHECK dout0_6 Vdout0_6ck162 = 1.8 time = 3260
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=3260.1n

* CHECK dout0_7 Vdout0_7ck162 = 1.8 time = 3260
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=3260.1n

* CHECK dout0_8 Vdout0_8ck162 = 1.8 time = 3260
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=3260.1n

* CHECK dout0_9 Vdout0_9ck162 = 0 time = 3260
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=3260.1n

* CHECK dout0_10 Vdout0_10ck162 = 0 time = 3260
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=3260.1n

* CHECK dout0_11 Vdout0_11ck162 = 0 time = 3260
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=3260.1n

* CHECK dout0_12 Vdout0_12ck162 = 1.8 time = 3260
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=3260.1n

* CHECK dout0_13 Vdout0_13ck162 = 0 time = 3260
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=3260.1n

* CHECK dout0_14 Vdout0_14ck162 = 1.8 time = 3260
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=3260.1n

* CHECK dout0_15 Vdout0_15ck162 = 0 time = 3260
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=3260.1n

* CHECK dout0_16 Vdout0_16ck162 = 0 time = 3260
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=3260.1n

* CHECK dout0_17 Vdout0_17ck162 = 1.8 time = 3260
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=3260.1n

* CHECK dout0_18 Vdout0_18ck162 = 0 time = 3260
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=3260.1n

* CHECK dout0_19 Vdout0_19ck162 = 0 time = 3260
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=3260.1n

* CHECK dout0_20 Vdout0_20ck162 = 1.8 time = 3260
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=3260.1n

* CHECK dout0_21 Vdout0_21ck162 = 0 time = 3260
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=3260.1n

* CHECK dout0_22 Vdout0_22ck162 = 1.8 time = 3260
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=3260.1n

* CHECK dout0_23 Vdout0_23ck162 = 1.8 time = 3260
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=3260.1n

* CHECK dout0_24 Vdout0_24ck162 = 0 time = 3260
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=3260.1n

* CHECK dout0_25 Vdout0_25ck162 = 0 time = 3260
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=3260.1n

* CHECK dout0_26 Vdout0_26ck162 = 1.8 time = 3260
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=3260.1n

* CHECK dout0_27 Vdout0_27ck162 = 0 time = 3260
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=3260.1n

* CHECK dout0_28 Vdout0_28ck162 = 0 time = 3260
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=3260.1n

* CHECK dout0_29 Vdout0_29ck162 = 0 time = 3260
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=3260.1n

* CHECK dout0_30 Vdout0_30ck162 = 1.8 time = 3260
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=3260.1n

* CHECK dout0_31 Vdout0_31ck162 = 0 time = 3260
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=3260.1n

* CHECK dout0_0 Vdout0_0ck165 = 1.8 time = 3320
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=3320.1n

* CHECK dout0_1 Vdout0_1ck165 = 0 time = 3320
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=3320.1n

* CHECK dout0_2 Vdout0_2ck165 = 0 time = 3320
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=3320.1n

* CHECK dout0_3 Vdout0_3ck165 = 1.8 time = 3320
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=3320.1n

* CHECK dout0_4 Vdout0_4ck165 = 0 time = 3320
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=3320.1n

* CHECK dout0_5 Vdout0_5ck165 = 1.8 time = 3320
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=3320.1n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 3320
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=3320.1n

* CHECK dout0_7 Vdout0_7ck165 = 0 time = 3320
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=3320.1n

* CHECK dout0_8 Vdout0_8ck165 = 1.8 time = 3320
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=3320.1n

* CHECK dout0_9 Vdout0_9ck165 = 1.8 time = 3320
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=3320.1n

* CHECK dout0_10 Vdout0_10ck165 = 0 time = 3320
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=3320.1n

* CHECK dout0_11 Vdout0_11ck165 = 0 time = 3320
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=3320.1n

* CHECK dout0_12 Vdout0_12ck165 = 0 time = 3320
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=3320.1n

* CHECK dout0_13 Vdout0_13ck165 = 1.8 time = 3320
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=3320.1n

* CHECK dout0_14 Vdout0_14ck165 = 1.8 time = 3320
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=3320.1n

* CHECK dout0_15 Vdout0_15ck165 = 1.8 time = 3320
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=3320.1n

* CHECK dout0_16 Vdout0_16ck165 = 0 time = 3320
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=3320.1n

* CHECK dout0_17 Vdout0_17ck165 = 0 time = 3320
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=3320.1n

* CHECK dout0_18 Vdout0_18ck165 = 0 time = 3320
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=3320.1n

* CHECK dout0_19 Vdout0_19ck165 = 1.8 time = 3320
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=3320.1n

* CHECK dout0_20 Vdout0_20ck165 = 0 time = 3320
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=3320.1n

* CHECK dout0_21 Vdout0_21ck165 = 1.8 time = 3320
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=3320.1n

* CHECK dout0_22 Vdout0_22ck165 = 1.8 time = 3320
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=3320.1n

* CHECK dout0_23 Vdout0_23ck165 = 1.8 time = 3320
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=3320.1n

* CHECK dout0_24 Vdout0_24ck165 = 0 time = 3320
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=3320.1n

* CHECK dout0_25 Vdout0_25ck165 = 1.8 time = 3320
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=3320.1n

* CHECK dout0_26 Vdout0_26ck165 = 1.8 time = 3320
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=3320.1n

* CHECK dout0_27 Vdout0_27ck165 = 0 time = 3320
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=3320.1n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 3320
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=3320.1n

* CHECK dout0_29 Vdout0_29ck165 = 0 time = 3320
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=3320.1n

* CHECK dout0_30 Vdout0_30ck165 = 1.8 time = 3320
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=3320.1n

* CHECK dout0_31 Vdout0_31ck165 = 0 time = 3320
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=3320.1n

* CHECK dout0_0 Vdout0_0ck166 = 1.8 time = 3340
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=3340.1n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 3340
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=3340.1n

* CHECK dout0_2 Vdout0_2ck166 = 0 time = 3340
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=3340.1n

* CHECK dout0_3 Vdout0_3ck166 = 0 time = 3340
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=3340.1n

* CHECK dout0_4 Vdout0_4ck166 = 1.8 time = 3340
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=3340.1n

* CHECK dout0_5 Vdout0_5ck166 = 1.8 time = 3340
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=3340.1n

* CHECK dout0_6 Vdout0_6ck166 = 1.8 time = 3340
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=3340.1n

* CHECK dout0_7 Vdout0_7ck166 = 1.8 time = 3340
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=3340.1n

* CHECK dout0_8 Vdout0_8ck166 = 1.8 time = 3340
.meas tran vdout0_8ck166 FIND v(dout0_8) AT=3340.1n

* CHECK dout0_9 Vdout0_9ck166 = 0 time = 3340
.meas tran vdout0_9ck166 FIND v(dout0_9) AT=3340.1n

* CHECK dout0_10 Vdout0_10ck166 = 0 time = 3340
.meas tran vdout0_10ck166 FIND v(dout0_10) AT=3340.1n

* CHECK dout0_11 Vdout0_11ck166 = 1.8 time = 3340
.meas tran vdout0_11ck166 FIND v(dout0_11) AT=3340.1n

* CHECK dout0_12 Vdout0_12ck166 = 0 time = 3340
.meas tran vdout0_12ck166 FIND v(dout0_12) AT=3340.1n

* CHECK dout0_13 Vdout0_13ck166 = 0 time = 3340
.meas tran vdout0_13ck166 FIND v(dout0_13) AT=3340.1n

* CHECK dout0_14 Vdout0_14ck166 = 0 time = 3340
.meas tran vdout0_14ck166 FIND v(dout0_14) AT=3340.1n

* CHECK dout0_15 Vdout0_15ck166 = 1.8 time = 3340
.meas tran vdout0_15ck166 FIND v(dout0_15) AT=3340.1n

* CHECK dout0_16 Vdout0_16ck166 = 1.8 time = 3340
.meas tran vdout0_16ck166 FIND v(dout0_16) AT=3340.1n

* CHECK dout0_17 Vdout0_17ck166 = 0 time = 3340
.meas tran vdout0_17ck166 FIND v(dout0_17) AT=3340.1n

* CHECK dout0_18 Vdout0_18ck166 = 0 time = 3340
.meas tran vdout0_18ck166 FIND v(dout0_18) AT=3340.1n

* CHECK dout0_19 Vdout0_19ck166 = 1.8 time = 3340
.meas tran vdout0_19ck166 FIND v(dout0_19) AT=3340.1n

* CHECK dout0_20 Vdout0_20ck166 = 0 time = 3340
.meas tran vdout0_20ck166 FIND v(dout0_20) AT=3340.1n

* CHECK dout0_21 Vdout0_21ck166 = 1.8 time = 3340
.meas tran vdout0_21ck166 FIND v(dout0_21) AT=3340.1n

* CHECK dout0_22 Vdout0_22ck166 = 1.8 time = 3340
.meas tran vdout0_22ck166 FIND v(dout0_22) AT=3340.1n

* CHECK dout0_23 Vdout0_23ck166 = 0 time = 3340
.meas tran vdout0_23ck166 FIND v(dout0_23) AT=3340.1n

* CHECK dout0_24 Vdout0_24ck166 = 0 time = 3340
.meas tran vdout0_24ck166 FIND v(dout0_24) AT=3340.1n

* CHECK dout0_25 Vdout0_25ck166 = 0 time = 3340
.meas tran vdout0_25ck166 FIND v(dout0_25) AT=3340.1n

* CHECK dout0_26 Vdout0_26ck166 = 1.8 time = 3340
.meas tran vdout0_26ck166 FIND v(dout0_26) AT=3340.1n

* CHECK dout0_27 Vdout0_27ck166 = 0 time = 3340
.meas tran vdout0_27ck166 FIND v(dout0_27) AT=3340.1n

* CHECK dout0_28 Vdout0_28ck166 = 0 time = 3340
.meas tran vdout0_28ck166 FIND v(dout0_28) AT=3340.1n

* CHECK dout0_29 Vdout0_29ck166 = 1.8 time = 3340
.meas tran vdout0_29ck166 FIND v(dout0_29) AT=3340.1n

* CHECK dout0_30 Vdout0_30ck166 = 1.8 time = 3340
.meas tran vdout0_30ck166 FIND v(dout0_30) AT=3340.1n

* CHECK dout0_31 Vdout0_31ck166 = 0 time = 3340
.meas tran vdout0_31ck166 FIND v(dout0_31) AT=3340.1n

* CHECK dout0_0 Vdout0_0ck168 = 1.8 time = 3380
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=3380.1n

* CHECK dout0_1 Vdout0_1ck168 = 1.8 time = 3380
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=3380.1n

* CHECK dout0_2 Vdout0_2ck168 = 0 time = 3380
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=3380.1n

* CHECK dout0_3 Vdout0_3ck168 = 1.8 time = 3380
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=3380.1n

* CHECK dout0_4 Vdout0_4ck168 = 1.8 time = 3380
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=3380.1n

* CHECK dout0_5 Vdout0_5ck168 = 0 time = 3380
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=3380.1n

* CHECK dout0_6 Vdout0_6ck168 = 0 time = 3380
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=3380.1n

* CHECK dout0_7 Vdout0_7ck168 = 0 time = 3380
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=3380.1n

* CHECK dout0_8 Vdout0_8ck168 = 0 time = 3380
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=3380.1n

* CHECK dout0_9 Vdout0_9ck168 = 0 time = 3380
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=3380.1n

* CHECK dout0_10 Vdout0_10ck168 = 1.8 time = 3380
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=3380.1n

* CHECK dout0_11 Vdout0_11ck168 = 1.8 time = 3380
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=3380.1n

* CHECK dout0_12 Vdout0_12ck168 = 0 time = 3380
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=3380.1n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 3380
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=3380.1n

* CHECK dout0_14 Vdout0_14ck168 = 1.8 time = 3380
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=3380.1n

* CHECK dout0_15 Vdout0_15ck168 = 1.8 time = 3380
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=3380.1n

* CHECK dout0_16 Vdout0_16ck168 = 1.8 time = 3380
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=3380.1n

* CHECK dout0_17 Vdout0_17ck168 = 0 time = 3380
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=3380.1n

* CHECK dout0_18 Vdout0_18ck168 = 1.8 time = 3380
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=3380.1n

* CHECK dout0_19 Vdout0_19ck168 = 0 time = 3380
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=3380.1n

* CHECK dout0_20 Vdout0_20ck168 = 0 time = 3380
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=3380.1n

* CHECK dout0_21 Vdout0_21ck168 = 1.8 time = 3380
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=3380.1n

* CHECK dout0_22 Vdout0_22ck168 = 0 time = 3380
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=3380.1n

* CHECK dout0_23 Vdout0_23ck168 = 1.8 time = 3380
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=3380.1n

* CHECK dout0_24 Vdout0_24ck168 = 1.8 time = 3380
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=3380.1n

* CHECK dout0_25 Vdout0_25ck168 = 0 time = 3380
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=3380.1n

* CHECK dout0_26 Vdout0_26ck168 = 1.8 time = 3380
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=3380.1n

* CHECK dout0_27 Vdout0_27ck168 = 1.8 time = 3380
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=3380.1n

* CHECK dout0_28 Vdout0_28ck168 = 1.8 time = 3380
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=3380.1n

* CHECK dout0_29 Vdout0_29ck168 = 1.8 time = 3380
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=3380.1n

* CHECK dout0_30 Vdout0_30ck168 = 1.8 time = 3380
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=3380.1n

* CHECK dout0_31 Vdout0_31ck168 = 0 time = 3380
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=3380.1n

* CHECK dout0_0 Vdout0_0ck170 = 1.8 time = 3420
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=3420.1n

* CHECK dout0_1 Vdout0_1ck170 = 0 time = 3420
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=3420.1n

* CHECK dout0_2 Vdout0_2ck170 = 1.8 time = 3420
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=3420.1n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 3420
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=3420.1n

* CHECK dout0_4 Vdout0_4ck170 = 1.8 time = 3420
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=3420.1n

* CHECK dout0_5 Vdout0_5ck170 = 0 time = 3420
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=3420.1n

* CHECK dout0_6 Vdout0_6ck170 = 0 time = 3420
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=3420.1n

* CHECK dout0_7 Vdout0_7ck170 = 1.8 time = 3420
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=3420.1n

* CHECK dout0_8 Vdout0_8ck170 = 1.8 time = 3420
.meas tran vdout0_8ck170 FIND v(dout0_8) AT=3420.1n

* CHECK dout0_9 Vdout0_9ck170 = 0 time = 3420
.meas tran vdout0_9ck170 FIND v(dout0_9) AT=3420.1n

* CHECK dout0_10 Vdout0_10ck170 = 1.8 time = 3420
.meas tran vdout0_10ck170 FIND v(dout0_10) AT=3420.1n

* CHECK dout0_11 Vdout0_11ck170 = 1.8 time = 3420
.meas tran vdout0_11ck170 FIND v(dout0_11) AT=3420.1n

* CHECK dout0_12 Vdout0_12ck170 = 0 time = 3420
.meas tran vdout0_12ck170 FIND v(dout0_12) AT=3420.1n

* CHECK dout0_13 Vdout0_13ck170 = 1.8 time = 3420
.meas tran vdout0_13ck170 FIND v(dout0_13) AT=3420.1n

* CHECK dout0_14 Vdout0_14ck170 = 1.8 time = 3420
.meas tran vdout0_14ck170 FIND v(dout0_14) AT=3420.1n

* CHECK dout0_15 Vdout0_15ck170 = 0 time = 3420
.meas tran vdout0_15ck170 FIND v(dout0_15) AT=3420.1n

* CHECK dout0_16 Vdout0_16ck170 = 1.8 time = 3420
.meas tran vdout0_16ck170 FIND v(dout0_16) AT=3420.1n

* CHECK dout0_17 Vdout0_17ck170 = 1.8 time = 3420
.meas tran vdout0_17ck170 FIND v(dout0_17) AT=3420.1n

* CHECK dout0_18 Vdout0_18ck170 = 1.8 time = 3420
.meas tran vdout0_18ck170 FIND v(dout0_18) AT=3420.1n

* CHECK dout0_19 Vdout0_19ck170 = 1.8 time = 3420
.meas tran vdout0_19ck170 FIND v(dout0_19) AT=3420.1n

* CHECK dout0_20 Vdout0_20ck170 = 1.8 time = 3420
.meas tran vdout0_20ck170 FIND v(dout0_20) AT=3420.1n

* CHECK dout0_21 Vdout0_21ck170 = 1.8 time = 3420
.meas tran vdout0_21ck170 FIND v(dout0_21) AT=3420.1n

* CHECK dout0_22 Vdout0_22ck170 = 0 time = 3420
.meas tran vdout0_22ck170 FIND v(dout0_22) AT=3420.1n

* CHECK dout0_23 Vdout0_23ck170 = 1.8 time = 3420
.meas tran vdout0_23ck170 FIND v(dout0_23) AT=3420.1n

* CHECK dout0_24 Vdout0_24ck170 = 1.8 time = 3420
.meas tran vdout0_24ck170 FIND v(dout0_24) AT=3420.1n

* CHECK dout0_25 Vdout0_25ck170 = 1.8 time = 3420
.meas tran vdout0_25ck170 FIND v(dout0_25) AT=3420.1n

* CHECK dout0_26 Vdout0_26ck170 = 0 time = 3420
.meas tran vdout0_26ck170 FIND v(dout0_26) AT=3420.1n

* CHECK dout0_27 Vdout0_27ck170 = 0 time = 3420
.meas tran vdout0_27ck170 FIND v(dout0_27) AT=3420.1n

* CHECK dout0_28 Vdout0_28ck170 = 1.8 time = 3420
.meas tran vdout0_28ck170 FIND v(dout0_28) AT=3420.1n

* CHECK dout0_29 Vdout0_29ck170 = 1.8 time = 3420
.meas tran vdout0_29ck170 FIND v(dout0_29) AT=3420.1n

* CHECK dout0_30 Vdout0_30ck170 = 0 time = 3420
.meas tran vdout0_30ck170 FIND v(dout0_30) AT=3420.1n

* CHECK dout0_31 Vdout0_31ck170 = 0 time = 3420
.meas tran vdout0_31ck170 FIND v(dout0_31) AT=3420.1n

* CHECK dout0_0 Vdout0_0ck175 = 1.8 time = 3520
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=3520.1n

* CHECK dout0_1 Vdout0_1ck175 = 1.8 time = 3520
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=3520.1n

* CHECK dout0_2 Vdout0_2ck175 = 0 time = 3520
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=3520.1n

* CHECK dout0_3 Vdout0_3ck175 = 1.8 time = 3520
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=3520.1n

* CHECK dout0_4 Vdout0_4ck175 = 1.8 time = 3520
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=3520.1n

* CHECK dout0_5 Vdout0_5ck175 = 0 time = 3520
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=3520.1n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 3520
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=3520.1n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 3520
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=3520.1n

* CHECK dout0_8 Vdout0_8ck175 = 0 time = 3520
.meas tran vdout0_8ck175 FIND v(dout0_8) AT=3520.1n

* CHECK dout0_9 Vdout0_9ck175 = 0 time = 3520
.meas tran vdout0_9ck175 FIND v(dout0_9) AT=3520.1n

* CHECK dout0_10 Vdout0_10ck175 = 1.8 time = 3520
.meas tran vdout0_10ck175 FIND v(dout0_10) AT=3520.1n

* CHECK dout0_11 Vdout0_11ck175 = 1.8 time = 3520
.meas tran vdout0_11ck175 FIND v(dout0_11) AT=3520.1n

* CHECK dout0_12 Vdout0_12ck175 = 0 time = 3520
.meas tran vdout0_12ck175 FIND v(dout0_12) AT=3520.1n

* CHECK dout0_13 Vdout0_13ck175 = 0 time = 3520
.meas tran vdout0_13ck175 FIND v(dout0_13) AT=3520.1n

* CHECK dout0_14 Vdout0_14ck175 = 1.8 time = 3520
.meas tran vdout0_14ck175 FIND v(dout0_14) AT=3520.1n

* CHECK dout0_15 Vdout0_15ck175 = 1.8 time = 3520
.meas tran vdout0_15ck175 FIND v(dout0_15) AT=3520.1n

* CHECK dout0_16 Vdout0_16ck175 = 1.8 time = 3520
.meas tran vdout0_16ck175 FIND v(dout0_16) AT=3520.1n

* CHECK dout0_17 Vdout0_17ck175 = 0 time = 3520
.meas tran vdout0_17ck175 FIND v(dout0_17) AT=3520.1n

* CHECK dout0_18 Vdout0_18ck175 = 1.8 time = 3520
.meas tran vdout0_18ck175 FIND v(dout0_18) AT=3520.1n

* CHECK dout0_19 Vdout0_19ck175 = 0 time = 3520
.meas tran vdout0_19ck175 FIND v(dout0_19) AT=3520.1n

* CHECK dout0_20 Vdout0_20ck175 = 0 time = 3520
.meas tran vdout0_20ck175 FIND v(dout0_20) AT=3520.1n

* CHECK dout0_21 Vdout0_21ck175 = 1.8 time = 3520
.meas tran vdout0_21ck175 FIND v(dout0_21) AT=3520.1n

* CHECK dout0_22 Vdout0_22ck175 = 0 time = 3520
.meas tran vdout0_22ck175 FIND v(dout0_22) AT=3520.1n

* CHECK dout0_23 Vdout0_23ck175 = 1.8 time = 3520
.meas tran vdout0_23ck175 FIND v(dout0_23) AT=3520.1n

* CHECK dout0_24 Vdout0_24ck175 = 1.8 time = 3520
.meas tran vdout0_24ck175 FIND v(dout0_24) AT=3520.1n

* CHECK dout0_25 Vdout0_25ck175 = 0 time = 3520
.meas tran vdout0_25ck175 FIND v(dout0_25) AT=3520.1n

* CHECK dout0_26 Vdout0_26ck175 = 1.8 time = 3520
.meas tran vdout0_26ck175 FIND v(dout0_26) AT=3520.1n

* CHECK dout0_27 Vdout0_27ck175 = 1.8 time = 3520
.meas tran vdout0_27ck175 FIND v(dout0_27) AT=3520.1n

* CHECK dout0_28 Vdout0_28ck175 = 1.8 time = 3520
.meas tran vdout0_28ck175 FIND v(dout0_28) AT=3520.1n

* CHECK dout0_29 Vdout0_29ck175 = 1.8 time = 3520
.meas tran vdout0_29ck175 FIND v(dout0_29) AT=3520.1n

* CHECK dout0_30 Vdout0_30ck175 = 1.8 time = 3520
.meas tran vdout0_30ck175 FIND v(dout0_30) AT=3520.1n

* CHECK dout0_31 Vdout0_31ck175 = 0 time = 3520
.meas tran vdout0_31ck175 FIND v(dout0_31) AT=3520.1n

* CHECK dout0_0 Vdout0_0ck176 = 0 time = 3540
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=3540.1n

* CHECK dout0_1 Vdout0_1ck176 = 0 time = 3540
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=3540.1n

* CHECK dout0_2 Vdout0_2ck176 = 1.8 time = 3540
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=3540.1n

* CHECK dout0_3 Vdout0_3ck176 = 1.8 time = 3540
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=3540.1n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 3540
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=3540.1n

* CHECK dout0_5 Vdout0_5ck176 = 1.8 time = 3540
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=3540.1n

* CHECK dout0_6 Vdout0_6ck176 = 1.8 time = 3540
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=3540.1n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 3540
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=3540.1n

* CHECK dout0_8 Vdout0_8ck176 = 0 time = 3540
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=3540.1n

* CHECK dout0_9 Vdout0_9ck176 = 0 time = 3540
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=3540.1n

* CHECK dout0_10 Vdout0_10ck176 = 0 time = 3540
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=3540.1n

* CHECK dout0_11 Vdout0_11ck176 = 0 time = 3540
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=3540.1n

* CHECK dout0_12 Vdout0_12ck176 = 0 time = 3540
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=3540.1n

* CHECK dout0_13 Vdout0_13ck176 = 1.8 time = 3540
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=3540.1n

* CHECK dout0_14 Vdout0_14ck176 = 1.8 time = 3540
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=3540.1n

* CHECK dout0_15 Vdout0_15ck176 = 1.8 time = 3540
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=3540.1n

* CHECK dout0_16 Vdout0_16ck176 = 1.8 time = 3540
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=3540.1n

* CHECK dout0_17 Vdout0_17ck176 = 0 time = 3540
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=3540.1n

* CHECK dout0_18 Vdout0_18ck176 = 1.8 time = 3540
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=3540.1n

* CHECK dout0_19 Vdout0_19ck176 = 1.8 time = 3540
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=3540.1n

* CHECK dout0_20 Vdout0_20ck176 = 1.8 time = 3540
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=3540.1n

* CHECK dout0_21 Vdout0_21ck176 = 1.8 time = 3540
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=3540.1n

* CHECK dout0_22 Vdout0_22ck176 = 1.8 time = 3540
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=3540.1n

* CHECK dout0_23 Vdout0_23ck176 = 0 time = 3540
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=3540.1n

* CHECK dout0_24 Vdout0_24ck176 = 1.8 time = 3540
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=3540.1n

* CHECK dout0_25 Vdout0_25ck176 = 1.8 time = 3540
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=3540.1n

* CHECK dout0_26 Vdout0_26ck176 = 0 time = 3540
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=3540.1n

* CHECK dout0_27 Vdout0_27ck176 = 0 time = 3540
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=3540.1n

* CHECK dout0_28 Vdout0_28ck176 = 0 time = 3540
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=3540.1n

* CHECK dout0_29 Vdout0_29ck176 = 0 time = 3540
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=3540.1n

* CHECK dout0_30 Vdout0_30ck176 = 0 time = 3540
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=3540.1n

* CHECK dout0_31 Vdout0_31ck176 = 0 time = 3540
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=3540.1n

* CHECK dout0_0 Vdout0_0ck177 = 1.8 time = 3560
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=3560.1n

* CHECK dout0_1 Vdout0_1ck177 = 0 time = 3560
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=3560.1n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 3560
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=3560.1n

* CHECK dout0_3 Vdout0_3ck177 = 0 time = 3560
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=3560.1n

* CHECK dout0_4 Vdout0_4ck177 = 1.8 time = 3560
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=3560.1n

* CHECK dout0_5 Vdout0_5ck177 = 1.8 time = 3560
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=3560.1n

* CHECK dout0_6 Vdout0_6ck177 = 1.8 time = 3560
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=3560.1n

* CHECK dout0_7 Vdout0_7ck177 = 1.8 time = 3560
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=3560.1n

* CHECK dout0_8 Vdout0_8ck177 = 1.8 time = 3560
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=3560.1n

* CHECK dout0_9 Vdout0_9ck177 = 0 time = 3560
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=3560.1n

* CHECK dout0_10 Vdout0_10ck177 = 0 time = 3560
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=3560.1n

* CHECK dout0_11 Vdout0_11ck177 = 1.8 time = 3560
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=3560.1n

* CHECK dout0_12 Vdout0_12ck177 = 0 time = 3560
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=3560.1n

* CHECK dout0_13 Vdout0_13ck177 = 0 time = 3560
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=3560.1n

* CHECK dout0_14 Vdout0_14ck177 = 0 time = 3560
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=3560.1n

* CHECK dout0_15 Vdout0_15ck177 = 1.8 time = 3560
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=3560.1n

* CHECK dout0_16 Vdout0_16ck177 = 1.8 time = 3560
.meas tran vdout0_16ck177 FIND v(dout0_16) AT=3560.1n

* CHECK dout0_17 Vdout0_17ck177 = 0 time = 3560
.meas tran vdout0_17ck177 FIND v(dout0_17) AT=3560.1n

* CHECK dout0_18 Vdout0_18ck177 = 0 time = 3560
.meas tran vdout0_18ck177 FIND v(dout0_18) AT=3560.1n

* CHECK dout0_19 Vdout0_19ck177 = 1.8 time = 3560
.meas tran vdout0_19ck177 FIND v(dout0_19) AT=3560.1n

* CHECK dout0_20 Vdout0_20ck177 = 0 time = 3560
.meas tran vdout0_20ck177 FIND v(dout0_20) AT=3560.1n

* CHECK dout0_21 Vdout0_21ck177 = 1.8 time = 3560
.meas tran vdout0_21ck177 FIND v(dout0_21) AT=3560.1n

* CHECK dout0_22 Vdout0_22ck177 = 1.8 time = 3560
.meas tran vdout0_22ck177 FIND v(dout0_22) AT=3560.1n

* CHECK dout0_23 Vdout0_23ck177 = 0 time = 3560
.meas tran vdout0_23ck177 FIND v(dout0_23) AT=3560.1n

* CHECK dout0_24 Vdout0_24ck177 = 0 time = 3560
.meas tran vdout0_24ck177 FIND v(dout0_24) AT=3560.1n

* CHECK dout0_25 Vdout0_25ck177 = 0 time = 3560
.meas tran vdout0_25ck177 FIND v(dout0_25) AT=3560.1n

* CHECK dout0_26 Vdout0_26ck177 = 1.8 time = 3560
.meas tran vdout0_26ck177 FIND v(dout0_26) AT=3560.1n

* CHECK dout0_27 Vdout0_27ck177 = 0 time = 3560
.meas tran vdout0_27ck177 FIND v(dout0_27) AT=3560.1n

* CHECK dout0_28 Vdout0_28ck177 = 0 time = 3560
.meas tran vdout0_28ck177 FIND v(dout0_28) AT=3560.1n

* CHECK dout0_29 Vdout0_29ck177 = 1.8 time = 3560
.meas tran vdout0_29ck177 FIND v(dout0_29) AT=3560.1n

* CHECK dout0_30 Vdout0_30ck177 = 1.8 time = 3560
.meas tran vdout0_30ck177 FIND v(dout0_30) AT=3560.1n

* CHECK dout0_31 Vdout0_31ck177 = 0 time = 3560
.meas tran vdout0_31ck177 FIND v(dout0_31) AT=3560.1n

* CHECK dout0_0 Vdout0_0ck178 = 1.8 time = 3580
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=3580.1n

* CHECK dout0_1 Vdout0_1ck178 = 0 time = 3580
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=3580.1n

* CHECK dout0_2 Vdout0_2ck178 = 0 time = 3580
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=3580.1n

* CHECK dout0_3 Vdout0_3ck178 = 1.8 time = 3580
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=3580.1n

* CHECK dout0_4 Vdout0_4ck178 = 0 time = 3580
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=3580.1n

* CHECK dout0_5 Vdout0_5ck178 = 1.8 time = 3580
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=3580.1n

* CHECK dout0_6 Vdout0_6ck178 = 0 time = 3580
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=3580.1n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 3580
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=3580.1n

* CHECK dout0_8 Vdout0_8ck178 = 1.8 time = 3580
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=3580.1n

* CHECK dout0_9 Vdout0_9ck178 = 1.8 time = 3580
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=3580.1n

* CHECK dout0_10 Vdout0_10ck178 = 0 time = 3580
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=3580.1n

* CHECK dout0_11 Vdout0_11ck178 = 0 time = 3580
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=3580.1n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 3580
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=3580.1n

* CHECK dout0_13 Vdout0_13ck178 = 1.8 time = 3580
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=3580.1n

* CHECK dout0_14 Vdout0_14ck178 = 1.8 time = 3580
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=3580.1n

* CHECK dout0_15 Vdout0_15ck178 = 1.8 time = 3580
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=3580.1n

* CHECK dout0_16 Vdout0_16ck178 = 0 time = 3580
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=3580.1n

* CHECK dout0_17 Vdout0_17ck178 = 0 time = 3580
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=3580.1n

* CHECK dout0_18 Vdout0_18ck178 = 0 time = 3580
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=3580.1n

* CHECK dout0_19 Vdout0_19ck178 = 1.8 time = 3580
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=3580.1n

* CHECK dout0_20 Vdout0_20ck178 = 0 time = 3580
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=3580.1n

* CHECK dout0_21 Vdout0_21ck178 = 1.8 time = 3580
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=3580.1n

* CHECK dout0_22 Vdout0_22ck178 = 1.8 time = 3580
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=3580.1n

* CHECK dout0_23 Vdout0_23ck178 = 1.8 time = 3580
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=3580.1n

* CHECK dout0_24 Vdout0_24ck178 = 0 time = 3580
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=3580.1n

* CHECK dout0_25 Vdout0_25ck178 = 1.8 time = 3580
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=3580.1n

* CHECK dout0_26 Vdout0_26ck178 = 1.8 time = 3580
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=3580.1n

* CHECK dout0_27 Vdout0_27ck178 = 0 time = 3580
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=3580.1n

* CHECK dout0_28 Vdout0_28ck178 = 0 time = 3580
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=3580.1n

* CHECK dout0_29 Vdout0_29ck178 = 0 time = 3580
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=3580.1n

* CHECK dout0_30 Vdout0_30ck178 = 1.8 time = 3580
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=3580.1n

* CHECK dout0_31 Vdout0_31ck178 = 0 time = 3580
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=3580.1n

* CHECK dout0_0 Vdout0_0ck180 = 1.8 time = 3620
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=3620.1n

* CHECK dout0_1 Vdout0_1ck180 = 1.8 time = 3620
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=3620.1n

* CHECK dout0_2 Vdout0_2ck180 = 0 time = 3620
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=3620.1n

* CHECK dout0_3 Vdout0_3ck180 = 1.8 time = 3620
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=3620.1n

* CHECK dout0_4 Vdout0_4ck180 = 1.8 time = 3620
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=3620.1n

* CHECK dout0_5 Vdout0_5ck180 = 0 time = 3620
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=3620.1n

* CHECK dout0_6 Vdout0_6ck180 = 0 time = 3620
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=3620.1n

* CHECK dout0_7 Vdout0_7ck180 = 0 time = 3620
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=3620.1n

* CHECK dout0_8 Vdout0_8ck180 = 0 time = 3620
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=3620.1n

* CHECK dout0_9 Vdout0_9ck180 = 0 time = 3620
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=3620.1n

* CHECK dout0_10 Vdout0_10ck180 = 1.8 time = 3620
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=3620.1n

* CHECK dout0_11 Vdout0_11ck180 = 1.8 time = 3620
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=3620.1n

* CHECK dout0_12 Vdout0_12ck180 = 0 time = 3620
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=3620.1n

* CHECK dout0_13 Vdout0_13ck180 = 0 time = 3620
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=3620.1n

* CHECK dout0_14 Vdout0_14ck180 = 1.8 time = 3620
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=3620.1n

* CHECK dout0_15 Vdout0_15ck180 = 1.8 time = 3620
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=3620.1n

* CHECK dout0_16 Vdout0_16ck180 = 1.8 time = 3620
.meas tran vdout0_16ck180 FIND v(dout0_16) AT=3620.1n

* CHECK dout0_17 Vdout0_17ck180 = 0 time = 3620
.meas tran vdout0_17ck180 FIND v(dout0_17) AT=3620.1n

* CHECK dout0_18 Vdout0_18ck180 = 1.8 time = 3620
.meas tran vdout0_18ck180 FIND v(dout0_18) AT=3620.1n

* CHECK dout0_19 Vdout0_19ck180 = 0 time = 3620
.meas tran vdout0_19ck180 FIND v(dout0_19) AT=3620.1n

* CHECK dout0_20 Vdout0_20ck180 = 0 time = 3620
.meas tran vdout0_20ck180 FIND v(dout0_20) AT=3620.1n

* CHECK dout0_21 Vdout0_21ck180 = 1.8 time = 3620
.meas tran vdout0_21ck180 FIND v(dout0_21) AT=3620.1n

* CHECK dout0_22 Vdout0_22ck180 = 0 time = 3620
.meas tran vdout0_22ck180 FIND v(dout0_22) AT=3620.1n

* CHECK dout0_23 Vdout0_23ck180 = 1.8 time = 3620
.meas tran vdout0_23ck180 FIND v(dout0_23) AT=3620.1n

* CHECK dout0_24 Vdout0_24ck180 = 1.8 time = 3620
.meas tran vdout0_24ck180 FIND v(dout0_24) AT=3620.1n

* CHECK dout0_25 Vdout0_25ck180 = 0 time = 3620
.meas tran vdout0_25ck180 FIND v(dout0_25) AT=3620.1n

* CHECK dout0_26 Vdout0_26ck180 = 1.8 time = 3620
.meas tran vdout0_26ck180 FIND v(dout0_26) AT=3620.1n

* CHECK dout0_27 Vdout0_27ck180 = 1.8 time = 3620
.meas tran vdout0_27ck180 FIND v(dout0_27) AT=3620.1n

* CHECK dout0_28 Vdout0_28ck180 = 1.8 time = 3620
.meas tran vdout0_28ck180 FIND v(dout0_28) AT=3620.1n

* CHECK dout0_29 Vdout0_29ck180 = 1.8 time = 3620
.meas tran vdout0_29ck180 FIND v(dout0_29) AT=3620.1n

* CHECK dout0_30 Vdout0_30ck180 = 1.8 time = 3620
.meas tran vdout0_30ck180 FIND v(dout0_30) AT=3620.1n

* CHECK dout0_31 Vdout0_31ck180 = 0 time = 3620
.meas tran vdout0_31ck180 FIND v(dout0_31) AT=3620.1n

* CHECK dout0_0 Vdout0_0ck185 = 1.8 time = 3720
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=3720.1n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 3720
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=3720.1n

* CHECK dout0_2 Vdout0_2ck185 = 1.8 time = 3720
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=3720.1n

* CHECK dout0_3 Vdout0_3ck185 = 0 time = 3720
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=3720.1n

* CHECK dout0_4 Vdout0_4ck185 = 1.8 time = 3720
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=3720.1n

* CHECK dout0_5 Vdout0_5ck185 = 0 time = 3720
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=3720.1n

* CHECK dout0_6 Vdout0_6ck185 = 0 time = 3720
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=3720.1n

* CHECK dout0_7 Vdout0_7ck185 = 1.8 time = 3720
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=3720.1n

* CHECK dout0_8 Vdout0_8ck185 = 1.8 time = 3720
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=3720.1n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 3720
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=3720.1n

* CHECK dout0_10 Vdout0_10ck185 = 1.8 time = 3720
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=3720.1n

* CHECK dout0_11 Vdout0_11ck185 = 1.8 time = 3720
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=3720.1n

* CHECK dout0_12 Vdout0_12ck185 = 0 time = 3720
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=3720.1n

* CHECK dout0_13 Vdout0_13ck185 = 1.8 time = 3720
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=3720.1n

* CHECK dout0_14 Vdout0_14ck185 = 1.8 time = 3720
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=3720.1n

* CHECK dout0_15 Vdout0_15ck185 = 0 time = 3720
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=3720.1n

* CHECK dout0_16 Vdout0_16ck185 = 1.8 time = 3720
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=3720.1n

* CHECK dout0_17 Vdout0_17ck185 = 1.8 time = 3720
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=3720.1n

* CHECK dout0_18 Vdout0_18ck185 = 1.8 time = 3720
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=3720.1n

* CHECK dout0_19 Vdout0_19ck185 = 1.8 time = 3720
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=3720.1n

* CHECK dout0_20 Vdout0_20ck185 = 1.8 time = 3720
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=3720.1n

* CHECK dout0_21 Vdout0_21ck185 = 1.8 time = 3720
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=3720.1n

* CHECK dout0_22 Vdout0_22ck185 = 0 time = 3720
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=3720.1n

* CHECK dout0_23 Vdout0_23ck185 = 1.8 time = 3720
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=3720.1n

* CHECK dout0_24 Vdout0_24ck185 = 1.8 time = 3720
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=3720.1n

* CHECK dout0_25 Vdout0_25ck185 = 1.8 time = 3720
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=3720.1n

* CHECK dout0_26 Vdout0_26ck185 = 0 time = 3720
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=3720.1n

* CHECK dout0_27 Vdout0_27ck185 = 0 time = 3720
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=3720.1n

* CHECK dout0_28 Vdout0_28ck185 = 1.8 time = 3720
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=3720.1n

* CHECK dout0_29 Vdout0_29ck185 = 1.8 time = 3720
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=3720.1n

* CHECK dout0_30 Vdout0_30ck185 = 0 time = 3720
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=3720.1n

* CHECK dout0_31 Vdout0_31ck185 = 0 time = 3720
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=3720.1n

* CHECK dout0_0 Vdout0_0ck186 = 1.8 time = 3740
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=3740.1n

* CHECK dout0_1 Vdout0_1ck186 = 1.8 time = 3740
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=3740.1n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 3740
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=3740.1n

* CHECK dout0_3 Vdout0_3ck186 = 1.8 time = 3740
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=3740.1n

* CHECK dout0_4 Vdout0_4ck186 = 1.8 time = 3740
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=3740.1n

* CHECK dout0_5 Vdout0_5ck186 = 0 time = 3740
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=3740.1n

* CHECK dout0_6 Vdout0_6ck186 = 0 time = 3740
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=3740.1n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 3740
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=3740.1n

* CHECK dout0_8 Vdout0_8ck186 = 0 time = 3740
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=3740.1n

* CHECK dout0_9 Vdout0_9ck186 = 0 time = 3740
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=3740.1n

* CHECK dout0_10 Vdout0_10ck186 = 1.8 time = 3740
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=3740.1n

* CHECK dout0_11 Vdout0_11ck186 = 1.8 time = 3740
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=3740.1n

* CHECK dout0_12 Vdout0_12ck186 = 0 time = 3740
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=3740.1n

* CHECK dout0_13 Vdout0_13ck186 = 0 time = 3740
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=3740.1n

* CHECK dout0_14 Vdout0_14ck186 = 1.8 time = 3740
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=3740.1n

* CHECK dout0_15 Vdout0_15ck186 = 1.8 time = 3740
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=3740.1n

* CHECK dout0_16 Vdout0_16ck186 = 1.8 time = 3740
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=3740.1n

* CHECK dout0_17 Vdout0_17ck186 = 0 time = 3740
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=3740.1n

* CHECK dout0_18 Vdout0_18ck186 = 1.8 time = 3740
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=3740.1n

* CHECK dout0_19 Vdout0_19ck186 = 0 time = 3740
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=3740.1n

* CHECK dout0_20 Vdout0_20ck186 = 0 time = 3740
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=3740.1n

* CHECK dout0_21 Vdout0_21ck186 = 1.8 time = 3740
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=3740.1n

* CHECK dout0_22 Vdout0_22ck186 = 0 time = 3740
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=3740.1n

* CHECK dout0_23 Vdout0_23ck186 = 1.8 time = 3740
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=3740.1n

* CHECK dout0_24 Vdout0_24ck186 = 1.8 time = 3740
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=3740.1n

* CHECK dout0_25 Vdout0_25ck186 = 0 time = 3740
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=3740.1n

* CHECK dout0_26 Vdout0_26ck186 = 1.8 time = 3740
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=3740.1n

* CHECK dout0_27 Vdout0_27ck186 = 1.8 time = 3740
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=3740.1n

* CHECK dout0_28 Vdout0_28ck186 = 1.8 time = 3740
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=3740.1n

* CHECK dout0_29 Vdout0_29ck186 = 1.8 time = 3740
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=3740.1n

* CHECK dout0_30 Vdout0_30ck186 = 1.8 time = 3740
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=3740.1n

* CHECK dout0_31 Vdout0_31ck186 = 0 time = 3740
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=3740.1n

* CHECK dout0_0 Vdout0_0ck191 = 1.8 time = 3840
.meas tran vdout0_0ck191 FIND v(dout0_0) AT=3840.1n

* CHECK dout0_1 Vdout0_1ck191 = 1.8 time = 3840
.meas tran vdout0_1ck191 FIND v(dout0_1) AT=3840.1n

* CHECK dout0_2 Vdout0_2ck191 = 0 time = 3840
.meas tran vdout0_2ck191 FIND v(dout0_2) AT=3840.1n

* CHECK dout0_3 Vdout0_3ck191 = 1.8 time = 3840
.meas tran vdout0_3ck191 FIND v(dout0_3) AT=3840.1n

* CHECK dout0_4 Vdout0_4ck191 = 1.8 time = 3840
.meas tran vdout0_4ck191 FIND v(dout0_4) AT=3840.1n

* CHECK dout0_5 Vdout0_5ck191 = 0 time = 3840
.meas tran vdout0_5ck191 FIND v(dout0_5) AT=3840.1n

* CHECK dout0_6 Vdout0_6ck191 = 0 time = 3840
.meas tran vdout0_6ck191 FIND v(dout0_6) AT=3840.1n

* CHECK dout0_7 Vdout0_7ck191 = 0 time = 3840
.meas tran vdout0_7ck191 FIND v(dout0_7) AT=3840.1n

* CHECK dout0_8 Vdout0_8ck191 = 0 time = 3840
.meas tran vdout0_8ck191 FIND v(dout0_8) AT=3840.1n

* CHECK dout0_9 Vdout0_9ck191 = 0 time = 3840
.meas tran vdout0_9ck191 FIND v(dout0_9) AT=3840.1n

* CHECK dout0_10 Vdout0_10ck191 = 1.8 time = 3840
.meas tran vdout0_10ck191 FIND v(dout0_10) AT=3840.1n

* CHECK dout0_11 Vdout0_11ck191 = 1.8 time = 3840
.meas tran vdout0_11ck191 FIND v(dout0_11) AT=3840.1n

* CHECK dout0_12 Vdout0_12ck191 = 0 time = 3840
.meas tran vdout0_12ck191 FIND v(dout0_12) AT=3840.1n

* CHECK dout0_13 Vdout0_13ck191 = 0 time = 3840
.meas tran vdout0_13ck191 FIND v(dout0_13) AT=3840.1n

* CHECK dout0_14 Vdout0_14ck191 = 1.8 time = 3840
.meas tran vdout0_14ck191 FIND v(dout0_14) AT=3840.1n

* CHECK dout0_15 Vdout0_15ck191 = 1.8 time = 3840
.meas tran vdout0_15ck191 FIND v(dout0_15) AT=3840.1n

* CHECK dout0_16 Vdout0_16ck191 = 1.8 time = 3840
.meas tran vdout0_16ck191 FIND v(dout0_16) AT=3840.1n

* CHECK dout0_17 Vdout0_17ck191 = 0 time = 3840
.meas tran vdout0_17ck191 FIND v(dout0_17) AT=3840.1n

* CHECK dout0_18 Vdout0_18ck191 = 1.8 time = 3840
.meas tran vdout0_18ck191 FIND v(dout0_18) AT=3840.1n

* CHECK dout0_19 Vdout0_19ck191 = 0 time = 3840
.meas tran vdout0_19ck191 FIND v(dout0_19) AT=3840.1n

* CHECK dout0_20 Vdout0_20ck191 = 0 time = 3840
.meas tran vdout0_20ck191 FIND v(dout0_20) AT=3840.1n

* CHECK dout0_21 Vdout0_21ck191 = 1.8 time = 3840
.meas tran vdout0_21ck191 FIND v(dout0_21) AT=3840.1n

* CHECK dout0_22 Vdout0_22ck191 = 0 time = 3840
.meas tran vdout0_22ck191 FIND v(dout0_22) AT=3840.1n

* CHECK dout0_23 Vdout0_23ck191 = 1.8 time = 3840
.meas tran vdout0_23ck191 FIND v(dout0_23) AT=3840.1n

* CHECK dout0_24 Vdout0_24ck191 = 1.8 time = 3840
.meas tran vdout0_24ck191 FIND v(dout0_24) AT=3840.1n

* CHECK dout0_25 Vdout0_25ck191 = 0 time = 3840
.meas tran vdout0_25ck191 FIND v(dout0_25) AT=3840.1n

* CHECK dout0_26 Vdout0_26ck191 = 1.8 time = 3840
.meas tran vdout0_26ck191 FIND v(dout0_26) AT=3840.1n

* CHECK dout0_27 Vdout0_27ck191 = 1.8 time = 3840
.meas tran vdout0_27ck191 FIND v(dout0_27) AT=3840.1n

* CHECK dout0_28 Vdout0_28ck191 = 1.8 time = 3840
.meas tran vdout0_28ck191 FIND v(dout0_28) AT=3840.1n

* CHECK dout0_29 Vdout0_29ck191 = 1.8 time = 3840
.meas tran vdout0_29ck191 FIND v(dout0_29) AT=3840.1n

* CHECK dout0_30 Vdout0_30ck191 = 1.8 time = 3840
.meas tran vdout0_30ck191 FIND v(dout0_30) AT=3840.1n

* CHECK dout0_31 Vdout0_31ck191 = 0 time = 3840
.meas tran vdout0_31ck191 FIND v(dout0_31) AT=3840.1n

* CHECK dout0_0 Vdout0_0ck192 = 1.8 time = 3860
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=3860.1n

* CHECK dout0_1 Vdout0_1ck192 = 1.8 time = 3860
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=3860.1n

* CHECK dout0_2 Vdout0_2ck192 = 0 time = 3860
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=3860.1n

* CHECK dout0_3 Vdout0_3ck192 = 1.8 time = 3860
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=3860.1n

* CHECK dout0_4 Vdout0_4ck192 = 1.8 time = 3860
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=3860.1n

* CHECK dout0_5 Vdout0_5ck192 = 0 time = 3860
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=3860.1n

* CHECK dout0_6 Vdout0_6ck192 = 0 time = 3860
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=3860.1n

* CHECK dout0_7 Vdout0_7ck192 = 0 time = 3860
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=3860.1n

* CHECK dout0_8 Vdout0_8ck192 = 0 time = 3860
.meas tran vdout0_8ck192 FIND v(dout0_8) AT=3860.1n

* CHECK dout0_9 Vdout0_9ck192 = 0 time = 3860
.meas tran vdout0_9ck192 FIND v(dout0_9) AT=3860.1n

* CHECK dout0_10 Vdout0_10ck192 = 1.8 time = 3860
.meas tran vdout0_10ck192 FIND v(dout0_10) AT=3860.1n

* CHECK dout0_11 Vdout0_11ck192 = 1.8 time = 3860
.meas tran vdout0_11ck192 FIND v(dout0_11) AT=3860.1n

* CHECK dout0_12 Vdout0_12ck192 = 0 time = 3860
.meas tran vdout0_12ck192 FIND v(dout0_12) AT=3860.1n

* CHECK dout0_13 Vdout0_13ck192 = 0 time = 3860
.meas tran vdout0_13ck192 FIND v(dout0_13) AT=3860.1n

* CHECK dout0_14 Vdout0_14ck192 = 1.8 time = 3860
.meas tran vdout0_14ck192 FIND v(dout0_14) AT=3860.1n

* CHECK dout0_15 Vdout0_15ck192 = 1.8 time = 3860
.meas tran vdout0_15ck192 FIND v(dout0_15) AT=3860.1n

* CHECK dout0_16 Vdout0_16ck192 = 1.8 time = 3860
.meas tran vdout0_16ck192 FIND v(dout0_16) AT=3860.1n

* CHECK dout0_17 Vdout0_17ck192 = 0 time = 3860
.meas tran vdout0_17ck192 FIND v(dout0_17) AT=3860.1n

* CHECK dout0_18 Vdout0_18ck192 = 1.8 time = 3860
.meas tran vdout0_18ck192 FIND v(dout0_18) AT=3860.1n

* CHECK dout0_19 Vdout0_19ck192 = 0 time = 3860
.meas tran vdout0_19ck192 FIND v(dout0_19) AT=3860.1n

* CHECK dout0_20 Vdout0_20ck192 = 0 time = 3860
.meas tran vdout0_20ck192 FIND v(dout0_20) AT=3860.1n

* CHECK dout0_21 Vdout0_21ck192 = 1.8 time = 3860
.meas tran vdout0_21ck192 FIND v(dout0_21) AT=3860.1n

* CHECK dout0_22 Vdout0_22ck192 = 0 time = 3860
.meas tran vdout0_22ck192 FIND v(dout0_22) AT=3860.1n

* CHECK dout0_23 Vdout0_23ck192 = 1.8 time = 3860
.meas tran vdout0_23ck192 FIND v(dout0_23) AT=3860.1n

* CHECK dout0_24 Vdout0_24ck192 = 1.8 time = 3860
.meas tran vdout0_24ck192 FIND v(dout0_24) AT=3860.1n

* CHECK dout0_25 Vdout0_25ck192 = 0 time = 3860
.meas tran vdout0_25ck192 FIND v(dout0_25) AT=3860.1n

* CHECK dout0_26 Vdout0_26ck192 = 1.8 time = 3860
.meas tran vdout0_26ck192 FIND v(dout0_26) AT=3860.1n

* CHECK dout0_27 Vdout0_27ck192 = 1.8 time = 3860
.meas tran vdout0_27ck192 FIND v(dout0_27) AT=3860.1n

* CHECK dout0_28 Vdout0_28ck192 = 1.8 time = 3860
.meas tran vdout0_28ck192 FIND v(dout0_28) AT=3860.1n

* CHECK dout0_29 Vdout0_29ck192 = 1.8 time = 3860
.meas tran vdout0_29ck192 FIND v(dout0_29) AT=3860.1n

* CHECK dout0_30 Vdout0_30ck192 = 1.8 time = 3860
.meas tran vdout0_30ck192 FIND v(dout0_30) AT=3860.1n

* CHECK dout0_31 Vdout0_31ck192 = 0 time = 3860
.meas tran vdout0_31ck192 FIND v(dout0_31) AT=3860.1n

* CHECK dout0_0 Vdout0_0ck193 = 1.8 time = 3880
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=3880.1n

* CHECK dout0_1 Vdout0_1ck193 = 0 time = 3880
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=3880.1n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 3880
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=3880.1n

* CHECK dout0_3 Vdout0_3ck193 = 0 time = 3880
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=3880.1n

* CHECK dout0_4 Vdout0_4ck193 = 1.8 time = 3880
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=3880.1n

* CHECK dout0_5 Vdout0_5ck193 = 1.8 time = 3880
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=3880.1n

* CHECK dout0_6 Vdout0_6ck193 = 1.8 time = 3880
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=3880.1n

* CHECK dout0_7 Vdout0_7ck193 = 1.8 time = 3880
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=3880.1n

* CHECK dout0_8 Vdout0_8ck193 = 1.8 time = 3880
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=3880.1n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 3880
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=3880.1n

* CHECK dout0_10 Vdout0_10ck193 = 0 time = 3880
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=3880.1n

* CHECK dout0_11 Vdout0_11ck193 = 1.8 time = 3880
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=3880.1n

* CHECK dout0_12 Vdout0_12ck193 = 0 time = 3880
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=3880.1n

* CHECK dout0_13 Vdout0_13ck193 = 0 time = 3880
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=3880.1n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 3880
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=3880.1n

* CHECK dout0_15 Vdout0_15ck193 = 1.8 time = 3880
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=3880.1n

* CHECK dout0_16 Vdout0_16ck193 = 1.8 time = 3880
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=3880.1n

* CHECK dout0_17 Vdout0_17ck193 = 0 time = 3880
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=3880.1n

* CHECK dout0_18 Vdout0_18ck193 = 0 time = 3880
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=3880.1n

* CHECK dout0_19 Vdout0_19ck193 = 1.8 time = 3880
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=3880.1n

* CHECK dout0_20 Vdout0_20ck193 = 0 time = 3880
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=3880.1n

* CHECK dout0_21 Vdout0_21ck193 = 1.8 time = 3880
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=3880.1n

* CHECK dout0_22 Vdout0_22ck193 = 1.8 time = 3880
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=3880.1n

* CHECK dout0_23 Vdout0_23ck193 = 0 time = 3880
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=3880.1n

* CHECK dout0_24 Vdout0_24ck193 = 0 time = 3880
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=3880.1n

* CHECK dout0_25 Vdout0_25ck193 = 0 time = 3880
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=3880.1n

* CHECK dout0_26 Vdout0_26ck193 = 1.8 time = 3880
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=3880.1n

* CHECK dout0_27 Vdout0_27ck193 = 0 time = 3880
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=3880.1n

* CHECK dout0_28 Vdout0_28ck193 = 0 time = 3880
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=3880.1n

* CHECK dout0_29 Vdout0_29ck193 = 1.8 time = 3880
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=3880.1n

* CHECK dout0_30 Vdout0_30ck193 = 1.8 time = 3880
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=3880.1n

* CHECK dout0_31 Vdout0_31ck193 = 0 time = 3880
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=3880.1n

* CHECK dout0_0 Vdout0_0ck194 = 1.8 time = 3900
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=3900.1n

* CHECK dout0_1 Vdout0_1ck194 = 0 time = 3900
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=3900.1n

* CHECK dout0_2 Vdout0_2ck194 = 1.8 time = 3900
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=3900.1n

* CHECK dout0_3 Vdout0_3ck194 = 0 time = 3900
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=3900.1n

* CHECK dout0_4 Vdout0_4ck194 = 1.8 time = 3900
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=3900.1n

* CHECK dout0_5 Vdout0_5ck194 = 1.8 time = 3900
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=3900.1n

* CHECK dout0_6 Vdout0_6ck194 = 1.8 time = 3900
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=3900.1n

* CHECK dout0_7 Vdout0_7ck194 = 1.8 time = 3900
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=3900.1n

* CHECK dout0_8 Vdout0_8ck194 = 0 time = 3900
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=3900.1n

* CHECK dout0_9 Vdout0_9ck194 = 1.8 time = 3900
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=3900.1n

* CHECK dout0_10 Vdout0_10ck194 = 1.8 time = 3900
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=3900.1n

* CHECK dout0_11 Vdout0_11ck194 = 0 time = 3900
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=3900.1n

* CHECK dout0_12 Vdout0_12ck194 = 1.8 time = 3900
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=3900.1n

* CHECK dout0_13 Vdout0_13ck194 = 0 time = 3900
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=3900.1n

* CHECK dout0_14 Vdout0_14ck194 = 1.8 time = 3900
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=3900.1n

* CHECK dout0_15 Vdout0_15ck194 = 0 time = 3900
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=3900.1n

* CHECK dout0_16 Vdout0_16ck194 = 1.8 time = 3900
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=3900.1n

* CHECK dout0_17 Vdout0_17ck194 = 1.8 time = 3900
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=3900.1n

* CHECK dout0_18 Vdout0_18ck194 = 0 time = 3900
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=3900.1n

* CHECK dout0_19 Vdout0_19ck194 = 0 time = 3900
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=3900.1n

* CHECK dout0_20 Vdout0_20ck194 = 1.8 time = 3900
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=3900.1n

* CHECK dout0_21 Vdout0_21ck194 = 1.8 time = 3900
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=3900.1n

* CHECK dout0_22 Vdout0_22ck194 = 0 time = 3900
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=3900.1n

* CHECK dout0_23 Vdout0_23ck194 = 1.8 time = 3900
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=3900.1n

* CHECK dout0_24 Vdout0_24ck194 = 1.8 time = 3900
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=3900.1n

* CHECK dout0_25 Vdout0_25ck194 = 0 time = 3900
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=3900.1n

* CHECK dout0_26 Vdout0_26ck194 = 1.8 time = 3900
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=3900.1n

* CHECK dout0_27 Vdout0_27ck194 = 0 time = 3900
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=3900.1n

* CHECK dout0_28 Vdout0_28ck194 = 0 time = 3900
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=3900.1n

* CHECK dout0_29 Vdout0_29ck194 = 1.8 time = 3900
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=3900.1n

* CHECK dout0_30 Vdout0_30ck194 = 1.8 time = 3900
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=3900.1n

* CHECK dout0_31 Vdout0_31ck194 = 0 time = 3900
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=3900.1n

* CHECK dout0_0 Vdout0_0ck197 = 1.8 time = 3960
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=3960.1n

* CHECK dout0_1 Vdout0_1ck197 = 1.8 time = 3960
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=3960.1n

* CHECK dout0_2 Vdout0_2ck197 = 0 time = 3960
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=3960.1n

* CHECK dout0_3 Vdout0_3ck197 = 1.8 time = 3960
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=3960.1n

* CHECK dout0_4 Vdout0_4ck197 = 1.8 time = 3960
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=3960.1n

* CHECK dout0_5 Vdout0_5ck197 = 0 time = 3960
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=3960.1n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 3960
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=3960.1n

* CHECK dout0_7 Vdout0_7ck197 = 0 time = 3960
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=3960.1n

* CHECK dout0_8 Vdout0_8ck197 = 0 time = 3960
.meas tran vdout0_8ck197 FIND v(dout0_8) AT=3960.1n

* CHECK dout0_9 Vdout0_9ck197 = 0 time = 3960
.meas tran vdout0_9ck197 FIND v(dout0_9) AT=3960.1n

* CHECK dout0_10 Vdout0_10ck197 = 1.8 time = 3960
.meas tran vdout0_10ck197 FIND v(dout0_10) AT=3960.1n

* CHECK dout0_11 Vdout0_11ck197 = 1.8 time = 3960
.meas tran vdout0_11ck197 FIND v(dout0_11) AT=3960.1n

* CHECK dout0_12 Vdout0_12ck197 = 0 time = 3960
.meas tran vdout0_12ck197 FIND v(dout0_12) AT=3960.1n

* CHECK dout0_13 Vdout0_13ck197 = 0 time = 3960
.meas tran vdout0_13ck197 FIND v(dout0_13) AT=3960.1n

* CHECK dout0_14 Vdout0_14ck197 = 1.8 time = 3960
.meas tran vdout0_14ck197 FIND v(dout0_14) AT=3960.1n

* CHECK dout0_15 Vdout0_15ck197 = 1.8 time = 3960
.meas tran vdout0_15ck197 FIND v(dout0_15) AT=3960.1n

* CHECK dout0_16 Vdout0_16ck197 = 1.8 time = 3960
.meas tran vdout0_16ck197 FIND v(dout0_16) AT=3960.1n

* CHECK dout0_17 Vdout0_17ck197 = 0 time = 3960
.meas tran vdout0_17ck197 FIND v(dout0_17) AT=3960.1n

* CHECK dout0_18 Vdout0_18ck197 = 1.8 time = 3960
.meas tran vdout0_18ck197 FIND v(dout0_18) AT=3960.1n

* CHECK dout0_19 Vdout0_19ck197 = 0 time = 3960
.meas tran vdout0_19ck197 FIND v(dout0_19) AT=3960.1n

* CHECK dout0_20 Vdout0_20ck197 = 0 time = 3960
.meas tran vdout0_20ck197 FIND v(dout0_20) AT=3960.1n

* CHECK dout0_21 Vdout0_21ck197 = 1.8 time = 3960
.meas tran vdout0_21ck197 FIND v(dout0_21) AT=3960.1n

* CHECK dout0_22 Vdout0_22ck197 = 0 time = 3960
.meas tran vdout0_22ck197 FIND v(dout0_22) AT=3960.1n

* CHECK dout0_23 Vdout0_23ck197 = 1.8 time = 3960
.meas tran vdout0_23ck197 FIND v(dout0_23) AT=3960.1n

* CHECK dout0_24 Vdout0_24ck197 = 1.8 time = 3960
.meas tran vdout0_24ck197 FIND v(dout0_24) AT=3960.1n

* CHECK dout0_25 Vdout0_25ck197 = 0 time = 3960
.meas tran vdout0_25ck197 FIND v(dout0_25) AT=3960.1n

* CHECK dout0_26 Vdout0_26ck197 = 1.8 time = 3960
.meas tran vdout0_26ck197 FIND v(dout0_26) AT=3960.1n

* CHECK dout0_27 Vdout0_27ck197 = 1.8 time = 3960
.meas tran vdout0_27ck197 FIND v(dout0_27) AT=3960.1n

* CHECK dout0_28 Vdout0_28ck197 = 1.8 time = 3960
.meas tran vdout0_28ck197 FIND v(dout0_28) AT=3960.1n

* CHECK dout0_29 Vdout0_29ck197 = 1.8 time = 3960
.meas tran vdout0_29ck197 FIND v(dout0_29) AT=3960.1n

* CHECK dout0_30 Vdout0_30ck197 = 1.8 time = 3960
.meas tran vdout0_30ck197 FIND v(dout0_30) AT=3960.1n

* CHECK dout0_31 Vdout0_31ck197 = 0 time = 3960
.meas tran vdout0_31ck197 FIND v(dout0_31) AT=3960.1n

* CHECK dout0_0 Vdout0_0ck199 = 1.8 time = 4000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=4000.1n

* CHECK dout0_1 Vdout0_1ck199 = 0 time = 4000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=4000.1n

* CHECK dout0_2 Vdout0_2ck199 = 1.8 time = 4000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=4000.1n

* CHECK dout0_3 Vdout0_3ck199 = 1.8 time = 4000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=4000.1n

* CHECK dout0_4 Vdout0_4ck199 = 1.8 time = 4000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=4000.1n

* CHECK dout0_5 Vdout0_5ck199 = 1.8 time = 4000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=4000.1n

* CHECK dout0_6 Vdout0_6ck199 = 1.8 time = 4000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=4000.1n

* CHECK dout0_7 Vdout0_7ck199 = 0 time = 4000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=4000.1n

* CHECK dout0_8 Vdout0_8ck199 = 1.8 time = 4000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=4000.1n

* CHECK dout0_9 Vdout0_9ck199 = 0 time = 4000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=4000.1n

* CHECK dout0_10 Vdout0_10ck199 = 1.8 time = 4000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=4000.1n

* CHECK dout0_11 Vdout0_11ck199 = 0 time = 4000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=4000.1n

* CHECK dout0_12 Vdout0_12ck199 = 1.8 time = 4000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=4000.1n

* CHECK dout0_13 Vdout0_13ck199 = 1.8 time = 4000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=4000.1n

* CHECK dout0_14 Vdout0_14ck199 = 1.8 time = 4000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=4000.1n

* CHECK dout0_15 Vdout0_15ck199 = 1.8 time = 4000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=4000.1n

* CHECK dout0_16 Vdout0_16ck199 = 0 time = 4000
.meas tran vdout0_16ck199 FIND v(dout0_16) AT=4000.1n

* CHECK dout0_17 Vdout0_17ck199 = 1.8 time = 4000
.meas tran vdout0_17ck199 FIND v(dout0_17) AT=4000.1n

* CHECK dout0_18 Vdout0_18ck199 = 0 time = 4000
.meas tran vdout0_18ck199 FIND v(dout0_18) AT=4000.1n

* CHECK dout0_19 Vdout0_19ck199 = 0 time = 4000
.meas tran vdout0_19ck199 FIND v(dout0_19) AT=4000.1n

* CHECK dout0_20 Vdout0_20ck199 = 1.8 time = 4000
.meas tran vdout0_20ck199 FIND v(dout0_20) AT=4000.1n

* CHECK dout0_21 Vdout0_21ck199 = 1.8 time = 4000
.meas tran vdout0_21ck199 FIND v(dout0_21) AT=4000.1n

* CHECK dout0_22 Vdout0_22ck199 = 1.8 time = 4000
.meas tran vdout0_22ck199 FIND v(dout0_22) AT=4000.1n

* CHECK dout0_23 Vdout0_23ck199 = 1.8 time = 4000
.meas tran vdout0_23ck199 FIND v(dout0_23) AT=4000.1n

* CHECK dout0_24 Vdout0_24ck199 = 0 time = 4000
.meas tran vdout0_24ck199 FIND v(dout0_24) AT=4000.1n

* CHECK dout0_25 Vdout0_25ck199 = 0 time = 4000
.meas tran vdout0_25ck199 FIND v(dout0_25) AT=4000.1n

* CHECK dout0_26 Vdout0_26ck199 = 0 time = 4000
.meas tran vdout0_26ck199 FIND v(dout0_26) AT=4000.1n

* CHECK dout0_27 Vdout0_27ck199 = 0 time = 4000
.meas tran vdout0_27ck199 FIND v(dout0_27) AT=4000.1n

* CHECK dout0_28 Vdout0_28ck199 = 0 time = 4000
.meas tran vdout0_28ck199 FIND v(dout0_28) AT=4000.1n

* CHECK dout0_29 Vdout0_29ck199 = 1.8 time = 4000
.meas tran vdout0_29ck199 FIND v(dout0_29) AT=4000.1n

* CHECK dout0_30 Vdout0_30ck199 = 0 time = 4000
.meas tran vdout0_30ck199 FIND v(dout0_30) AT=4000.1n

* CHECK dout0_31 Vdout0_31ck199 = 0 time = 4000
.meas tran vdout0_31ck199 FIND v(dout0_31) AT=4000.1n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
